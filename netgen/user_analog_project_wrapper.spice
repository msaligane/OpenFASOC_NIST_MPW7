* NGSPICE file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt sky130_fd_pr__res_generic_nd_SDEVQU a_n3502_1521# a_n3502_n1215# a_n3625_n1337#
X0 a_n3502_n1215# a_n3502_1521# a_n3625_n1337# sky130_fd_pr__res_generic_nd w=420000u l=6.8616e+08u
.ends

.subckt x228k_ndiff_resistor sky130_fd_pr__res_generic_nd_SDEVQU_0/a_n3502_1521# VSUBS
+ sky130_fd_pr__res_generic_nd_SDEVQU_0/a_n3502_n1215#
Xsky130_fd_pr__res_generic_nd_SDEVQU_0 sky130_fd_pr__res_generic_nd_SDEVQU_0/a_n3502_1521#
+ sky130_fd_pr__res_generic_nd_SDEVQU_0/a_n3502_n1215# VSUBS sky130_fd_pr__res_generic_nd_SDEVQU
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_9B94PP$4 c1_n738_n688# m3_n838_n788#
X0 c1_n738_n688# m3_n838_n788# sky130_fd_pr__cap_mim_m3_1 l=6.88e+06u w=6.88e+06u
.ends

.subckt x100f_capacitor$4 sky130_fd_pr__cap_mim_m3_1_9B94PP$4_0/c1_n738_n688# sky130_fd_pr__cap_mim_m3_1_9B94PP$4_0/m3_n838_n788#
Xsky130_fd_pr__cap_mim_m3_1_9B94PP$4_0 sky130_fd_pr__cap_mim_m3_1_9B94PP$4_0/c1_n738_n688#
+ sky130_fd_pr__cap_mim_m3_1_9B94PP$4_0/m3_n838_n788# sky130_fd_pr__cap_mim_m3_1_9B94PP$4
.ends

.subckt sky130_fd_pr__nfet_01v8_BP3WK9$4 a_2167_n5338# a_1967_n5426# a_1909_n5338#
+ a_1807_n5512#
X0 a_2167_n5338# a_1967_n5426# a_1909_n5338# a_1807_n5512# sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt x1w1l_nmos$4 sky130_fd_pr__nfet_01v8_BP3WK9$4_0/a_2167_n5338# sky130_fd_pr__nfet_01v8_BP3WK9$4_0/a_1967_n5426#
+ sky130_fd_pr__nfet_01v8_BP3WK9$4_0/a_1909_n5338# VSUBS
Xsky130_fd_pr__nfet_01v8_BP3WK9$4_0 sky130_fd_pr__nfet_01v8_BP3WK9$4_0/a_2167_n5338#
+ sky130_fd_pr__nfet_01v8_BP3WK9$4_0/a_1967_n5426# sky130_fd_pr__nfet_01v8_BP3WK9$4_0/a_1909_n5338#
+ VSUBS sky130_fd_pr__nfet_01v8_BP3WK9$4
.ends

.subckt sky130_fd_pr__pfet_01v8_9GKHW3$4 a_n2270_11865# a_n2012_11865# a_n2212_11768#
+ w_n2408_11646#
X0 a_n2012_11865# a_n2212_11768# a_n2270_11865# w_n2408_11646# sky130_fd_pr__pfet_01v8 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
.ends

.subckt x2w1l_pmos$4 sky130_fd_pr__pfet_01v8_9GKHW3$4_0/a_n2212_11768# sky130_fd_pr__pfet_01v8_9GKHW3$4_0/a_n2270_11865#
+ sky130_fd_pr__pfet_01v8_9GKHW3$4_0/w_n2408_11646# sky130_fd_pr__pfet_01v8_9GKHW3$4_0/a_n2012_11865#
Xsky130_fd_pr__pfet_01v8_9GKHW3$4_0 sky130_fd_pr__pfet_01v8_9GKHW3$4_0/a_n2270_11865#
+ sky130_fd_pr__pfet_01v8_9GKHW3$4_0/a_n2012_11865# sky130_fd_pr__pfet_01v8_9GKHW3$4_0/a_n2212_11768#
+ sky130_fd_pr__pfet_01v8_9GKHW3$4_0/w_n2408_11646# sky130_fd_pr__pfet_01v8_9GKHW3$4
.ends

.subckt TIA_228k Vdd Vout Iin gnd
X228k_ndiff_resistor_0 Iin gnd li_n3188_n2637# x228k_ndiff_resistor
X100f_capacitor$4_0 Vout li_n3188_n2637# x100f_capacitor$4
X1w1l_nmos$4_0 li_n3188_n2637# Iin gnd gnd x1w1l_nmos$4
X2w1l_pmos$4_0 Iin Vdd Vdd li_n3188_n2637# x2w1l_pmos$4
.ends

.subckt x2G4 a_22237_n20625#
X0 a_22625_n12699# w_22452_n20410# a_22237_n20625# sky130_fd_pr__cap_var w=5e+06u l=1e+07u
X1 a_22237_n20625# a_24184_n23920# a_24184_n23920# a_22237_n20625# sky130_fd_pr__nfet_01v8 ad=3.6395e+13p pd=2.5738e+08u as=7.54e+12p ps=5.432e+07u w=6.5e+06u l=150000u
X2 a_22237_n20625# a_22826_n25802# a_22237_n20625# a_22237_n20625# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2e+07u l=150000u
X3 a_22625_n12699# w_22452_n20410# a_22237_n20625# sky130_fd_pr__cap_var w=5e+06u l=1e+07u
X4 a_22625_n20367# w_22452_n20410# a_22237_n20625# sky130_fd_pr__cap_var w=5e+06u l=1e+07u
X5 a_22625_n12699# w_22452_n20410# a_22237_n20625# sky130_fd_pr__cap_var w=5e+06u l=1e+07u
X6 a_22237_n20625# a_24184_n23920# a_24184_n23920# a_22237_n20625# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.5e+06u l=150000u
X7 a_22625_n20367# w_22452_n20410# a_22237_n20625# sky130_fd_pr__cap_var w=5e+06u l=1e+07u
X8 a_22237_n20625# a_24184_n23920# a_22237_n20625# a_22237_n20625# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.5e+06u l=150000u
X9 a_24184_n23920# a_24184_n23920# a_22237_n20625# a_22237_n20625# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.5e+06u l=150000u
X10 a_22237_n20625# a_22826_n25802# a_22237_n20625# a_22237_n20625# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2e+07u l=150000u
X11 a_22625_n12699# w_22452_n20410# a_22237_n20625# sky130_fd_pr__cap_var w=5e+06u l=1e+07u
X12 a_22625_n20367# w_22452_n20410# a_22237_n20625# sky130_fd_pr__cap_var w=5e+06u l=1e+07u
X13 a_22237_n20625# a_22826_n25802# a_22237_n20625# a_22237_n20625# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2e+07u l=150000u
X14 a_22625_n12699# w_22452_n20410# a_22237_n20625# sky130_fd_pr__cap_var w=5e+06u l=1e+07u
X15 a_22625_n12699# w_22452_n20410# a_22237_n20625# sky130_fd_pr__cap_var w=5e+06u l=1e+07u
X16 a_22625_n20367# w_22452_n20410# a_22237_n20625# sky130_fd_pr__cap_var w=5e+06u l=1e+07u
X17 a_22625_n12699# w_22452_n20410# a_22237_n20625# sky130_fd_pr__cap_var w=5e+06u l=1e+07u
X18 a_22625_n20367# w_22452_n20410# a_22237_n20625# sky130_fd_pr__cap_var w=5e+06u l=1e+07u
X19 a_24184_n23920# a_24184_n23920# a_22237_n20625# a_22237_n20625# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.5e+06u l=150000u
X20 a_22237_n20625# a_24184_n23920# a_24184_n23920# a_22237_n20625# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.5e+06u l=150000u
X21 a_22237_n20625# a_24184_n23920# a_24184_n23920# a_22237_n20625# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.5e+06u l=150000u
X22 a_24184_n23920# a_24184_n23920# a_22237_n20625# a_22237_n20625# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.5e+06u l=150000u
X23 a_22625_n20367# w_22452_n20410# a_22237_n20625# sky130_fd_pr__cap_var w=5e+06u l=1e+07u
X24 a_22625_n12699# w_22452_n20410# a_22237_n20625# sky130_fd_pr__cap_var w=5e+06u l=1e+07u
X25 a_22625_n20367# w_22452_n20410# a_22237_n20625# sky130_fd_pr__cap_var w=5e+06u l=1e+07u
X26 a_22625_n20367# w_22452_n20410# a_22237_n20625# sky130_fd_pr__cap_var w=5e+06u l=1e+07u
X27 a_22237_n20625# a_24184_n23920# a_22237_n20625# a_22237_n20625# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.5e+06u l=150000u
X28 a_24184_n23920# a_24184_n23920# a_22237_n20625# a_22237_n20625# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.5e+06u l=150000u
.ends

.subckt sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2 RST VDD Ib D1 D2 D3 D4 D5 D6 D7 D1-N
+ D2-N D3-N-a D3-P-b D3-N-b D4-N-a D4-P-b D4-N-b D5-N-a D5-N-b D5-P-b D5-P-c D5-N-c
+ D6-N-a D6-N-b GND D7-N-c D7-N-b D7-N-a a_12347_63503# w_12412_197573# w_12412_185573#
+ w_12312_17573# w_12304_209497# w_12398_101543# w_12304_233497# li_5732_3953# w_12304_221497#
+ w_12204_53497# w_12592_149753#
X0 VDD w_12092_n6647# D1 GND sky130_fd_pr__nfet_01v8_lvt ad=1.3398e+13p pd=1.0052e+08u as=1.914e+12p ps=1.436e+07u w=3.3e+06u l=300000u
X1 VDD dw_12172_65433# D7 GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=1.914e+12p ps=1.436e+07u w=3.3e+06u l=300000u
X2 D5 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=6.699e+12p ps=5.026e+07u w=3.3e+06u l=300000u
X3 D4 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=0p ps=0u w=3.3e+06u l=300000u
X4 D1 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X5 w_12092_n6647# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=1.46957e+14p pd=2.9918e+08u as=0p ps=0u w=3.3e+06u l=300000u
X6 D6 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=0p ps=0u w=3.3e+06u l=300000u
X7 D2 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=0p ps=0u w=3.3e+06u l=300000u
D0 GND dw_12092_17353# sky130_fd_pr__model__parasitic__diode_ps2dn area=1e+14p
X8 VDD dw_12012_41273# D5 GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X9 VDD dw_12046_29291# D4 GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
D1 GND D6-N-b sky130_fd_pr__model__parasitic__diode_ps2dn area=1e+14p
X10 D3 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=0p ps=0u w=3.3e+06u l=300000u
X11 VDD dw_11948_53241# D6 GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X12 VDD a_12092_5353# D2 GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
D2 GND D7-N-a sky130_fd_pr__model__parasitic__diode_ps2dn area=3.2768e+14p
X13 dw_12172_65433# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=9.5165e+13p pd=3.0158e+08u as=0p ps=0u w=3.3e+06u l=300000u
X14 VDD dw_12092_17353# D3 GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
D3 GND D7-N-b sky130_fd_pr__model__parasitic__diode_ps2dn area=3.2768e+14p
D4 GND dw_14032_235353# sky130_fd_pr__model__parasitic__diode_ps2dn area=3.2768e+14p
X15 dw_11948_53241# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=1.01821e+14p pd=3.2078e+08u as=0p ps=0u w=3.3e+06u l=300000u
D5 GND dw_11948_53241# sky130_fd_pr__model__parasitic__diode_ps2dn area=3.2768e+14p
X16 a_12092_5353# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=1.42696e+15p pd=1.6118e+08u as=0p ps=0u w=3.3e+06u l=300000u
D6 GND D6-N-a sky130_fd_pr__model__parasitic__diode_ps2dn area=1e+14p
X17 dw_12092_17353# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=7.7957e+13p pd=3.1518e+08u as=0p ps=0u w=3.3e+06u l=300000u
X18 D7 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X19 dw_12012_41273# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=1.0608e+15p pd=4.3118e+08u as=0p ps=0u w=3.3e+06u l=300000u
X20 dw_12046_29291# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=9.6213e+13p pd=3.0958e+08u as=0p ps=0u w=3.3e+06u l=300000u
.ends

.subckt sky130_fd_pr__nfet_01v8_PTDE5C$2 a_499_1522# a_342_1436# a_444_1610#
X0 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=1.0527e+13p pd=7.898e+07u as=9.57e+12p ps=7.18e+07u w=3.3e+06u l=300000u
X1 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X2 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X3 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X4 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X5 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X6 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X7 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X8 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X9 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X10 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X11 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X12 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X13 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X14 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X15 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X16 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X17 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X18 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X19 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
.ends

.subckt sky130_fd_pr__diode_pw2nd_05v5_VLZ7RW$1 a_n500_n500# a_n602_n602#
D0 a_n602_n602# a_n500_n500# sky130_fd_pr__diode_pw2nd_05v5 pj=2e+07u area=2.5e+13p
.ends

.subckt photo_V3 sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D5-P-c sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D5-P-b
+ w_10320_189420# w_10320_201420# w_10112_57344# sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D3-P-b
+ w_10500_153600# w_10306_105390# w_10212_237344# w_10212_225344# w_10212_213344#
+ w_10220_21420# sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/GND
Xsky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0 sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/RST
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/VDD sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/Ib
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D1 sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D2
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D3 sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D4
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D5 sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D6
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D7 sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D1-N
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D2-N sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D3-N-a
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D3-P-b sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D3-N-b
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D4-N-a sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D4-P-b
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D4-N-b sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D5-N-a
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D5-N-b sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D5-P-b
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D5-P-c sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D5-N-c
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D6-N-a sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D6-N-b
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/GND sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D7-N-c
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D7-N-b sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D7-N-a
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/Ib w_10320_201420# w_10320_189420# w_10220_21420#
+ w_10212_213344# w_10306_105390# w_10212_237344# sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/GND
+ w_10212_225344# w_10112_57344# w_10500_153600# sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2
Xsky130_fd_pr__nfet_01v8_PTDE5C$2_0 sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/Ib sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/GND
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/GND sky130_fd_pr__nfet_01v8_PTDE5C$2
Xsky130_fd_pr__diode_pw2nd_05v5_VLZ7RW$1_0 sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/RST
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/GND sky130_fd_pr__diode_pw2nd_05v5_VLZ7RW$1
.ends

.subckt x10G a_21787_n17615#
X0 a_21787_n17615# a_22872_n12668# a_21787_n17615# a_21787_n17615# sky130_fd_pr__nfet_01v8 ad=8.7145e+13p pd=6.0796e+08u as=0p ps=0u w=2.15e+07u l=150000u
X1 a_21787_n17615# a_21916_n17446# a_22082_n17398# a_21787_n17615# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=3.48e+13p ps=2.4232e+08u w=3e+07u l=150000u
X2 a_22082_n17398# a_21916_n17446# a_21787_n17615# a_21787_n17615# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+07u l=150000u
X3 a_21787_n17615# a_21916_n17446# a_22082_n17398# a_21787_n17615# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+07u l=150000u
X4 a_22872_n12668# a_22732_n12422# a_21787_n17615# a_21787_n17615# sky130_fd_pr__nfet_01v8 ad=1.247e+13p pd=8.716e+07u as=0p ps=0u w=2.15e+07u l=150000u
X5 a_22872_n12668# a_22732_n12422# a_21787_n17615# a_21787_n17615# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.15e+07u l=150000u
X6 a_21787_n17615# a_22872_n12668# a_22732_n12422# a_21787_n17615# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.247e+13p ps=8.716e+07u w=2.15e+07u l=150000u
X7 a_22082_n17398# a_21916_n17446# a_21787_n17615# a_21787_n17615# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+07u l=150000u
X8 a_22082_n17398# a_21916_n17446# a_21787_n17615# a_21787_n17615# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+07u l=150000u
X9 a_21787_n17615# a_22732_n12422# a_21787_n17615# a_21787_n17615# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.15e+07u l=150000u
X10 a_22732_n12422# a_22872_n12668# a_21787_n17615# a_21787_n17615# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.15e+07u l=150000u
X11 a_21787_n17615# a_21916_n17446# a_22082_n17398# a_21787_n17615# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+07u l=150000u
X12 a_21787_n17615# a_22872_n12668# a_22732_n12422# a_21787_n17615# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.15e+07u l=150000u
X13 a_22732_n12422# a_22872_n12668# a_21787_n17615# a_21787_n17615# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.15e+07u l=150000u
X14 a_22082_n17398# a_21916_n17446# a_21787_n17615# a_21787_n17615# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+07u l=150000u
X15 a_21787_n17615# a_21916_n17446# a_22082_n17398# a_21787_n17615# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+07u l=150000u
X16 a_21787_n17615# a_22732_n12422# a_22872_n12668# a_21787_n17615# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.15e+07u l=150000u
X17 a_21787_n17615# a_22732_n12422# a_22872_n12668# a_21787_n17615# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.15e+07u l=150000u
.ends

.subckt sky130_fd_pr__nfet_01v8_lvt_D7LUG4$1 a_12347_63503# w_12298_29543# w_12312_17573#
+ m1_3292_n7247# w_12204_53497#
X0 a_12690_63591# w_12092_n6647# a_12450_3501# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=1.3398e+13p pd=1.0052e+08u as=1.914e+12p ps=1.436e+07u w=3.3e+06u l=300000u
X1 a_12690_63591# dw_12172_65433# a_12426_75607# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=1.914e+12p ps=1.436e+07u w=3.3e+06u l=300000u
X2 a_12426_51575# a_12347_63503# w_12298_29543# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=6.699e+12p ps=5.026e+07u w=3.3e+06u l=300000u
X3 a_12427_39564# a_12347_63503# w_12298_29543# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=0p ps=0u w=3.3e+06u l=300000u
X4 a_12450_3501# a_12347_63503# w_12298_29543# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X5 w_12092_n6647# a_12907_64271# a_12690_63591# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=1.46957e+14p pd=2.9918e+08u as=0p ps=0u w=3.3e+06u l=300000u
X6 a_12410_63591# a_12347_63503# w_12298_29543# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=0p ps=0u w=3.3e+06u l=300000u
X7 a_12430_15421# a_12347_63503# w_12298_29543# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=0p ps=0u w=3.3e+06u l=300000u
D0 w_12298_29543# dw_12092_17353# sky130_fd_pr__model__parasitic__diode_ps2dn area=1e+14p
X8 a_12690_63591# dw_12012_41273# a_12426_51575# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X9 a_12690_63591# dw_12046_29291# a_12427_39564# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X10 a_12450_27381# a_12347_63503# w_12298_29543# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=0p ps=0u w=3.3e+06u l=300000u
X11 a_12690_63591# dw_11948_53241# a_12410_63591# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X12 a_12690_63591# a_12092_5353# a_12430_15421# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X13 dw_12172_65433# a_12907_64271# a_12690_63591# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=9.5165e+13p pd=3.0158e+08u as=0p ps=0u w=3.3e+06u l=300000u
X14 a_12690_63591# dw_12092_17353# a_12450_27381# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X15 dw_11948_53241# a_12907_64271# a_12690_63591# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=1.01821e+14p pd=3.2078e+08u as=0p ps=0u w=3.3e+06u l=300000u
D1 w_12298_29543# dw_11948_53241# sky130_fd_pr__model__parasitic__diode_ps2dn area=3.2768e+14p
X16 a_12092_5353# a_12907_64271# a_12690_63591# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=1.42696e+15p pd=1.6118e+08u as=0p ps=0u w=3.3e+06u l=300000u
X17 dw_12092_17353# a_12907_64271# a_12690_63591# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=7.7957e+13p pd=3.1518e+08u as=0p ps=0u w=3.3e+06u l=300000u
X18 a_12426_75607# a_12347_63503# w_12298_29543# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X19 dw_12012_41273# a_12907_64271# a_12690_63591# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=1.0608e+15p pd=4.3118e+08u as=0p ps=0u w=3.3e+06u l=300000u
X20 dw_12046_29291# a_12907_64271# a_12690_63591# w_12298_29543# sky130_fd_pr__nfet_01v8_lvt ad=9.6213e+13p pd=3.0958e+08u as=0p ps=0u w=3.3e+06u l=300000u
.ends

.subckt sky130_fd_pr__nfet_01v8_PTDE5C$1 a_499_1522# a_342_1436# a_444_1610#
X0 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=1.0527e+13p pd=7.898e+07u as=9.57e+12p ps=7.18e+07u w=3.3e+06u l=300000u
X1 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X2 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X3 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X4 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X5 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X6 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X7 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X8 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X9 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X10 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X11 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X12 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X13 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X14 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X15 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X16 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X17 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X18 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X19 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
.ends

.subckt photo_V1 w_10112_57344# w_10220_21420# VSUBS
Xsky130_fd_pr__nfet_01v8_lvt_D7LUG4$1_0 sky130_fd_pr__nfet_01v8_PTDE5C$1_0/a_499_1522#
+ VSUBS w_10220_21420# sky130_fd_pr__nfet_01v8_PTDE5C$1_0/a_499_1522# w_10112_57344#
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$1
Xsky130_fd_pr__nfet_01v8_PTDE5C$1_0 sky130_fd_pr__nfet_01v8_PTDE5C$1_0/a_499_1522#
+ VSUBS VSUBS sky130_fd_pr__nfet_01v8_PTDE5C$1
.ends

.subckt varactors4september
.ends

.subckt sky130_fd_pr__pfet_01v8_9GKHW3$3 a_n2270_11865# a_n2012_11865# a_n2212_11768#
+ w_n2408_11646#
X0 a_n2012_11865# a_n2212_11768# a_n2270_11865# w_n2408_11646# sky130_fd_pr__pfet_01v8 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
.ends

.subckt x2w1l_pmos$3 sky130_fd_pr__pfet_01v8_9GKHW3$3_0/w_n2408_11646# sky130_fd_pr__pfet_01v8_9GKHW3$3_0/a_n2012_11865#
+ sky130_fd_pr__pfet_01v8_9GKHW3$3_0/a_n2212_11768# sky130_fd_pr__pfet_01v8_9GKHW3$3_0/a_n2270_11865#
Xsky130_fd_pr__pfet_01v8_9GKHW3$3_0 sky130_fd_pr__pfet_01v8_9GKHW3$3_0/a_n2270_11865#
+ sky130_fd_pr__pfet_01v8_9GKHW3$3_0/a_n2012_11865# sky130_fd_pr__pfet_01v8_9GKHW3$3_0/a_n2212_11768#
+ sky130_fd_pr__pfet_01v8_9GKHW3$3_0/w_n2408_11646# sky130_fd_pr__pfet_01v8_9GKHW3$3
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_9B94PP$3 c1_n738_n688# m3_n838_n788#
X0 c1_n738_n688# m3_n838_n788# sky130_fd_pr__cap_mim_m3_1 l=6.88e+06u w=6.88e+06u
.ends

.subckt x100f_capacitor$3 sky130_fd_pr__cap_mim_m3_1_9B94PP$3_0/m3_n838_n788# sky130_fd_pr__cap_mim_m3_1_9B94PP$3_0/c1_n738_n688#
Xsky130_fd_pr__cap_mim_m3_1_9B94PP$3_0 sky130_fd_pr__cap_mim_m3_1_9B94PP$3_0/c1_n738_n688#
+ sky130_fd_pr__cap_mim_m3_1_9B94PP$3_0/m3_n838_n788# sky130_fd_pr__cap_mim_m3_1_9B94PP$3
.ends

.subckt sky130_fd_pr__res_generic_nd_ZL93MZ a_n1410_n5123# a_1326_n5123# a_n1532_n5246#
X0 a_n1410_n5123# a_1326_n5123# a_n1532_n5246# sky130_fd_pr__res_generic_nd w=420000u l=1.00816e+09u
.ends

.subckt x332k_ndiff_resistor sky130_fd_pr__res_generic_nd_ZL93MZ_0/a_1326_n5123# sky130_fd_pr__res_generic_nd_ZL93MZ_0/a_n1410_n5123#
+ VSUBS
Xsky130_fd_pr__res_generic_nd_ZL93MZ_0 sky130_fd_pr__res_generic_nd_ZL93MZ_0/a_n1410_n5123#
+ sky130_fd_pr__res_generic_nd_ZL93MZ_0/a_1326_n5123# VSUBS sky130_fd_pr__res_generic_nd_ZL93MZ
.ends

.subckt sky130_fd_pr__nfet_01v8_BP3WK9$3 a_2167_n5338# a_1967_n5426# a_1909_n5338#
+ a_1807_n5512#
X0 a_2167_n5338# a_1967_n5426# a_1909_n5338# a_1807_n5512# sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt x1w1l_nmos$3 sky130_fd_pr__nfet_01v8_BP3WK9$3_0/a_2167_n5338# sky130_fd_pr__nfet_01v8_BP3WK9$3_0/a_1967_n5426#
+ sky130_fd_pr__nfet_01v8_BP3WK9$3_0/a_1909_n5338# VSUBS
Xsky130_fd_pr__nfet_01v8_BP3WK9$3_0 sky130_fd_pr__nfet_01v8_BP3WK9$3_0/a_2167_n5338#
+ sky130_fd_pr__nfet_01v8_BP3WK9$3_0/a_1967_n5426# sky130_fd_pr__nfet_01v8_BP3WK9$3_0/a_1909_n5338#
+ VSUBS sky130_fd_pr__nfet_01v8_BP3WK9$3
.ends

.subckt TIA_332k Vdd Vout Iin gnd
X2w1l_pmos$3_0 Vdd li_n5042_n2631# Iin Vdd x2w1l_pmos$3
X100f_capacitor$3_0 li_n5042_n2631# Vout x100f_capacitor$3
X332k_ndiff_resistor_0 li_n5042_n2631# Iin gnd x332k_ndiff_resistor
X1w1l_nmos$3_0 li_n5042_n2631# Iin gnd gnd x1w1l_nmos$3
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_8NU5HM$2 c1_n2155_n7555# m3_n7444_n7655# m3_n2255_n7655#
+ m3_n7444_n2565# c1_3034_n7555# m3_2934_n7655# c1_n7344_n7555#
X0 c1_n7344_n7555# m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X1 c1_n2155_n7555# m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X2 c1_n7344_n7555# m3_n7444_n2565# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X3 c1_n2155_n7555# m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X4 c1_3034_n7555# m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X5 c1_3034_n7555# m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X6 c1_n2155_n7555# m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X7 c1_3034_n7555# m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X8 c1_n7344_n7555# m3_n7444_n2565# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
.ends

.subckt x10p_capacitor$2 sky130_fd_pr__cap_mim_m3_1_8NU5HM$2_0/m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1_8NU5HM$2_0/m3_n7444_n2565#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$2_0/c1_n7344_n7555# sky130_fd_pr__cap_mim_m3_1_8NU5HM$2_0/c1_3034_n7555#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$2_0/m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1_8NU5HM$2_0/c1_n2155_n7555#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$2_0/m3_n7444_n7655#
Xsky130_fd_pr__cap_mim_m3_1_8NU5HM$2_0 sky130_fd_pr__cap_mim_m3_1_8NU5HM$2_0/c1_n2155_n7555#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$2_0/m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1_8NU5HM$2_0/m3_n2255_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$2_0/m3_n7444_n2565# sky130_fd_pr__cap_mim_m3_1_8NU5HM$2_0/c1_3034_n7555#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$2_0/m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1_8NU5HM$2_0/c1_n7344_n7555#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$2
.ends

.subckt sky130_fd_pr__nfet_01v8_28DC9G$1 a_n150_n788# a_n310_n874# a_150_n700# a_n208_n700#
X0 a_150_n700# a_n150_n788# a_n208_n700# a_n310_n874# sky130_fd_pr__nfet_01v8 ad=2.03e+12p pd=1.458e+07u as=2.03e+12p ps=1.458e+07u w=7e+06u l=1.5e+06u
.ends

.subckt x7w1_5l_nmos$1 sky130_fd_pr__nfet_01v8_28DC9G$1_0/a_n208_n700# sky130_fd_pr__nfet_01v8_28DC9G$1_0/a_n150_n788#
+ sky130_fd_pr__nfet_01v8_28DC9G$1_0/a_150_n700# VSUBS
Xsky130_fd_pr__nfet_01v8_28DC9G$1_0 sky130_fd_pr__nfet_01v8_28DC9G$1_0/a_n150_n788#
+ VSUBS sky130_fd_pr__nfet_01v8_28DC9G$1_0/a_150_n700# sky130_fd_pr__nfet_01v8_28DC9G$1_0/a_n208_n700#
+ sky130_fd_pr__nfet_01v8_28DC9G$1
.ends

.subckt sky130_fd_pr__nfet_01v8_6BSMN9$6$1 a_800_n42# a_n960_n216# a_n858_n42# a_n800_n130#
X0 a_800_n42# a_n800_n130# a_n858_n42# a_n960_n216# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt x024w8l_nmos$6$1 sky130_fd_pr__nfet_01v8_6BSMN9$6$1_0/a_n858_n42# sky130_fd_pr__nfet_01v8_6BSMN9$6$1_0/a_800_n42#
+ sky130_fd_pr__nfet_01v8_6BSMN9$6$1_0/a_n800_n130# VSUBS
Xsky130_fd_pr__nfet_01v8_6BSMN9$6$1_0 sky130_fd_pr__nfet_01v8_6BSMN9$6$1_0/a_800_n42#
+ VSUBS sky130_fd_pr__nfet_01v8_6BSMN9$6$1_0/a_n858_n42# sky130_fd_pr__nfet_01v8_6BSMN9$6$1_0/a_n800_n130#
+ sky130_fd_pr__nfet_01v8_6BSMN9$6$1
.ends

.subckt sky130_fd_pr__nfet_01v8_ZEJXTR$1 a_42_n5000# a_n202_n5174# a_n42_n5088# a_n100_n5000#
X0 a_42_n5000# a_n42_n5088# a_n100_n5000# a_n202_n5174# sky130_fd_pr__nfet_01v8 ad=1.45e+13p pd=1.0058e+08u as=1.45e+13p ps=1.0058e+08u w=5e+07u l=420000u
.ends

.subckt x50w042l_nmos$1 sky130_fd_pr__nfet_01v8_ZEJXTR$1_0/a_n100_n5000# sky130_fd_pr__nfet_01v8_ZEJXTR$1_0/a_n42_n5088#
+ sky130_fd_pr__nfet_01v8_ZEJXTR$1_0/a_42_n5000# VSUBS
Xsky130_fd_pr__nfet_01v8_ZEJXTR$1_0 sky130_fd_pr__nfet_01v8_ZEJXTR$1_0/a_42_n5000#
+ VSUBS sky130_fd_pr__nfet_01v8_ZEJXTR$1_0/a_n42_n5088# sky130_fd_pr__nfet_01v8_ZEJXTR$1_0/a_n100_n5000#
+ sky130_fd_pr__nfet_01v8_ZEJXTR$1
.ends

.subckt sky130_fd_pr__pfet_01v8_589FFS$1$1 w_n996_n261# a_n800_n139# a_800_n42# a_n858_n42#
X0 a_800_n42# a_n800_n139# a_n858_n42# w_n996_n261# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt x042w8l_pmos$1$1 sky130_fd_pr__pfet_01v8_589FFS$1$1_0/w_n996_n261# sky130_fd_pr__pfet_01v8_589FFS$1$1_0/a_n800_n139#
+ sky130_fd_pr__pfet_01v8_589FFS$1$1_0/a_n858_n42# sky130_fd_pr__pfet_01v8_589FFS$1$1_0/a_800_n42#
Xsky130_fd_pr__pfet_01v8_589FFS$1$1_0 sky130_fd_pr__pfet_01v8_589FFS$1$1_0/w_n996_n261#
+ sky130_fd_pr__pfet_01v8_589FFS$1$1_0/a_n800_n139# sky130_fd_pr__pfet_01v8_589FFS$1$1_0/a_800_n42#
+ sky130_fd_pr__pfet_01v8_589FFS$1$1_0/a_n858_n42# sky130_fd_pr__pfet_01v8_589FFS$1$1
.ends

.subckt sky130_fd_pr__pfet_01v8_U2PZU3$1$1 w_n238_n261# a_n100_n42# a_n42_n139# a_42_n42#
X0 a_42_n42# a_n42_n139# a_n100_n42# w_n238_n261# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=420000u
.ends

.subckt x042w042l_pmos$1$1 sky130_fd_pr__pfet_01v8_U2PZU3$1$1_0/a_n42_n139# sky130_fd_pr__pfet_01v8_U2PZU3$1$1_0/a_n100_n42#
+ sky130_fd_pr__pfet_01v8_U2PZU3$1$1_0/w_n238_n261# sky130_fd_pr__pfet_01v8_U2PZU3$1$1_0/a_42_n42#
Xsky130_fd_pr__pfet_01v8_U2PZU3$1$1_0 sky130_fd_pr__pfet_01v8_U2PZU3$1$1_0/w_n238_n261#
+ sky130_fd_pr__pfet_01v8_U2PZU3$1$1_0/a_n100_n42# sky130_fd_pr__pfet_01v8_U2PZU3$1$1_0/a_n42_n139#
+ sky130_fd_pr__pfet_01v8_U2PZU3$1$1_0/a_42_n42# sky130_fd_pr__pfet_01v8_U2PZU3$1$1
.ends

.subckt sky130_fd_pr__pfet_01v8_GJQV38$1 w_n546_n919# a_n350_n797# a_350_n700# a_n408_n700#
X0 a_350_n700# a_n350_n797# a_n408_n700# w_n546_n919# sky130_fd_pr__pfet_01v8 ad=2.03e+12p pd=1.458e+07u as=2.03e+12p ps=1.458e+07u w=7e+06u l=3.5e+06u
.ends

.subckt x7w3_5l_pmos$1 sky130_fd_pr__pfet_01v8_GJQV38$1_0/a_n408_n700# sky130_fd_pr__pfet_01v8_GJQV38$1_0/a_350_n700#
+ sky130_fd_pr__pfet_01v8_GJQV38$1_0/w_n546_n919# sky130_fd_pr__pfet_01v8_GJQV38$1_0/a_n350_n797#
Xsky130_fd_pr__pfet_01v8_GJQV38$1_0 sky130_fd_pr__pfet_01v8_GJQV38$1_0/w_n546_n919#
+ sky130_fd_pr__pfet_01v8_GJQV38$1_0/a_n350_n797# sky130_fd_pr__pfet_01v8_GJQV38$1_0/a_350_n700#
+ sky130_fd_pr__pfet_01v8_GJQV38$1_0/a_n408_n700# sky130_fd_pr__pfet_01v8_GJQV38$1
.ends

.subckt sky130_fd_pr__nfet_01v8_6BSMN9$5$1 a_800_n42# a_n960_n216# a_n858_n42# a_n800_n130#
X0 a_800_n42# a_n800_n130# a_n858_n42# a_n960_n216# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt x024w8l_nmos$5$1 sky130_fd_pr__nfet_01v8_6BSMN9$5$1_0/a_800_n42# sky130_fd_pr__nfet_01v8_6BSMN9$5$1_0/a_n858_n42#
+ sky130_fd_pr__nfet_01v8_6BSMN9$5$1_0/a_n800_n130# VSUBS
Xsky130_fd_pr__nfet_01v8_6BSMN9$5$1_0 sky130_fd_pr__nfet_01v8_6BSMN9$5$1_0/a_800_n42#
+ VSUBS sky130_fd_pr__nfet_01v8_6BSMN9$5$1_0/a_n858_n42# sky130_fd_pr__nfet_01v8_6BSMN9$5$1_0/a_n800_n130#
+ sky130_fd_pr__nfet_01v8_6BSMN9$5$1
.ends

.subckt sky130_fd_pr__pfet_01v8_HWZHW3$2 a_100_n5000# a_n158_n5000# a_n100_n5097#
+ w_n296_n5219#
X0 a_100_n5000# a_n100_n5097# a_n158_n5000# w_n296_n5219# sky130_fd_pr__pfet_01v8 ad=1.45e+13p pd=1.0058e+08u as=1.45e+13p ps=1.0058e+08u w=5e+07u l=1e+06u
.ends

.subckt x50w1l_pmos$2 sky130_fd_pr__pfet_01v8_HWZHW3$2_0/a_n158_n5000# sky130_fd_pr__pfet_01v8_HWZHW3$2_0/a_n100_n5097#
+ sky130_fd_pr__pfet_01v8_HWZHW3$2_0/w_n296_n5219# sky130_fd_pr__pfet_01v8_HWZHW3$2_0/a_100_n5000#
Xsky130_fd_pr__pfet_01v8_HWZHW3$2_0 sky130_fd_pr__pfet_01v8_HWZHW3$2_0/a_100_n5000#
+ sky130_fd_pr__pfet_01v8_HWZHW3$2_0/a_n158_n5000# sky130_fd_pr__pfet_01v8_HWZHW3$2_0/a_n100_n5097#
+ sky130_fd_pr__pfet_01v8_HWZHW3$2_0/w_n296_n5219# sky130_fd_pr__pfet_01v8_HWZHW3$2
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$1 c1_n2155_n7555# m3_n7444_n7655# m3_n2255_n7655#
+ c1_3034_n7555# m3_2934_n7655# c1_n7344_n7555#
X0 c1_n7344_n7555# m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X1 c1_n2155_n7555# m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X2 c1_n7344_n7555# m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X3 c1_n2155_n7555# m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X4 c1_3034_n7555# m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X5 c1_3034_n7555# m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X6 c1_n2155_n7555# m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X7 c1_3034_n7555# m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X8 c1_n7344_n7555# m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
.ends

.subckt x10p_capacitor$1$1 sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$1_0/m3_n2255_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$1_0/c1_3034_n7555# sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$1_0/m3_2934_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$1_0/c1_n7344_n7555# sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$1_0/m3_n7444_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$1_0/c1_n2155_n7555#
Xsky130_fd_pr__cap_mim_m3_1_8NU5HM$1$1_0 sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$1_0/c1_n2155_n7555#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$1_0/m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$1_0/m3_n2255_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$1_0/c1_3034_n7555# sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$1_0/m3_2934_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$1_0/c1_n7344_n7555# sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$1
.ends

.subckt sky130_fd_pr__pfet_01v8_U2PZU3$2 w_n238_n261# a_n100_n42# a_n42_n139# a_42_n42#
X0 a_42_n42# a_n42_n139# a_n100_n42# w_n238_n261# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=420000u
.ends

.subckt x042w042l_pmos$2 sky130_fd_pr__pfet_01v8_U2PZU3$2_0/w_n238_n261# sky130_fd_pr__pfet_01v8_U2PZU3$2_0/a_42_n42#
+ sky130_fd_pr__pfet_01v8_U2PZU3$2_0/a_n42_n139# sky130_fd_pr__pfet_01v8_U2PZU3$2_0/a_n100_n42#
Xsky130_fd_pr__pfet_01v8_U2PZU3$2_0 sky130_fd_pr__pfet_01v8_U2PZU3$2_0/w_n238_n261#
+ sky130_fd_pr__pfet_01v8_U2PZU3$2_0/a_n100_n42# sky130_fd_pr__pfet_01v8_U2PZU3$2_0/a_n42_n139#
+ sky130_fd_pr__pfet_01v8_U2PZU3$2_0/a_42_n42# sky130_fd_pr__pfet_01v8_U2PZU3$2
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_9B94PP$1 c1_n738_n928# m3_n838_n1028#
X0 c1_n738_n928# m3_n838_n1028# sky130_fd_pr__cap_mim_m3_1 l=6.88e+06u w=6.88e+06u
.ends

.subckt x100f_capacitor$1 sky130_fd_pr__cap_mim_m3_1_9B94PP$1_0/m3_n838_n1028# sky130_fd_pr__cap_mim_m3_1_9B94PP$1_0/c1_n738_n928#
Xsky130_fd_pr__cap_mim_m3_1_9B94PP$1_0 sky130_fd_pr__cap_mim_m3_1_9B94PP$1_0/c1_n738_n928#
+ sky130_fd_pr__cap_mim_m3_1_9B94PP$1_0/m3_n838_n1028# sky130_fd_pr__cap_mim_m3_1_9B94PP$1
.ends

.subckt pads$8 single_pad$2_0[1|0]/m1_n12006_n4000# single_pad$2_0[0|3]/m1_n12006_n4000#
+ single_pad$2_0[1|5]/m1_n12006_n4000# single_pad$2_0[0|0]/m1_n12006_n4000# single_pad$2_0[1|2]/m1_n12006_n4000#
+ single_pad$2_0[0|5]/m1_n12006_n4000# single_pad$2_0[0|2]/m1_n12006_n4000# single_pad$2_0[1|4]/m1_n12006_n4000#
+ single_pad$2_0[1|1]/m1_n12006_n4000# single_pad$2_0[0|4]/m1_n12006_n4000# single_pad$2_0[0|1]/m1_n12006_n4000#
+ single_pad$2_0[1|3]/m1_n12006_n4000#
.ends

.subckt sky130_fd_pr__pfet_01v8_HWZHW3$1$1 a_100_n5000# a_n158_n5000# a_n100_n5097#
+ w_n296_n5219#
X0 a_100_n5000# a_n100_n5097# a_n158_n5000# w_n296_n5219# sky130_fd_pr__pfet_01v8 ad=1.45e+13p pd=1.0058e+08u as=1.45e+13p ps=1.0058e+08u w=5e+07u l=1e+06u
.ends

.subckt x50w1l_pmos$1$1 sky130_fd_pr__pfet_01v8_HWZHW3$1$1_0/a_n158_n5000# sky130_fd_pr__pfet_01v8_HWZHW3$1$1_0/a_n100_n5097#
+ sky130_fd_pr__pfet_01v8_HWZHW3$1$1_0/a_100_n5000# sky130_fd_pr__pfet_01v8_HWZHW3$1$1_0/w_n296_n5219#
Xsky130_fd_pr__pfet_01v8_HWZHW3$1$1_0 sky130_fd_pr__pfet_01v8_HWZHW3$1$1_0/a_100_n5000#
+ sky130_fd_pr__pfet_01v8_HWZHW3$1$1_0/a_n158_n5000# sky130_fd_pr__pfet_01v8_HWZHW3$1$1_0/a_n100_n5097#
+ sky130_fd_pr__pfet_01v8_HWZHW3$1$1_0/w_n296_n5219# sky130_fd_pr__pfet_01v8_HWZHW3$1$1
.ends

.subckt sky130_fd_pr__nfet_01v8_6BSMN9$7$1 a_800_n42# a_n960_n216# a_n858_n42# a_n800_n130#
X0 a_800_n42# a_n800_n130# a_n858_n42# a_n960_n216# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt x024w8l_nmos$7$1 sky130_fd_pr__nfet_01v8_6BSMN9$7$1_0/a_n800_n130# sky130_fd_pr__nfet_01v8_6BSMN9$7$1_0/a_800_n42#
+ sky130_fd_pr__nfet_01v8_6BSMN9$7$1_0/a_n858_n42# VSUBS
Xsky130_fd_pr__nfet_01v8_6BSMN9$7$1_0 sky130_fd_pr__nfet_01v8_6BSMN9$7$1_0/a_800_n42#
+ VSUBS sky130_fd_pr__nfet_01v8_6BSMN9$7$1_0/a_n858_n42# sky130_fd_pr__nfet_01v8_6BSMN9$7$1_0/a_n800_n130#
+ sky130_fd_pr__nfet_01v8_6BSMN9$7$1
.ends

.subckt sky130_fd_pr__nfet_01v8_6BSMN9$8 a_800_n42# a_n960_n216# a_n858_n42# a_n800_n130#
X0 a_800_n42# a_n800_n130# a_n858_n42# a_n960_n216# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt x024w8l_nmos$8 sky130_fd_pr__nfet_01v8_6BSMN9$8_0/a_n858_n42# sky130_fd_pr__nfet_01v8_6BSMN9$8_0/a_n800_n130#
+ sky130_fd_pr__nfet_01v8_6BSMN9$8_0/a_800_n42# VSUBS
Xsky130_fd_pr__nfet_01v8_6BSMN9$8_0 sky130_fd_pr__nfet_01v8_6BSMN9$8_0/a_800_n42#
+ VSUBS sky130_fd_pr__nfet_01v8_6BSMN9$8_0/a_n858_n42# sky130_fd_pr__nfet_01v8_6BSMN9$8_0/a_n800_n130#
+ sky130_fd_pr__nfet_01v8_6BSMN9$8
.ends

.subckt X1$1 w_n5371_n1923# a_n5223_n127# a_n5223_n1785# a_n5249_n1727#
X0 a_n5223_n127# a_n5249_n1727# a_n5223_n1785# w_n5371_n1923# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X4$1 a_n5074_164# a_n5248_n1596# a_n5074_n1494# a_n5162_n1436#
X0 a_n5074_164# a_n5162_n1436# a_n5074_n1494# a_n5248_n1596# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X7$1 a_n7416_n4222# a_n7330_n4062# a_n7242_n4120# a_n7242_n2462#
X0 a_n7242_n2462# a_n7330_n4062# a_n7242_n4120# a_n7416_n4222# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X0$1 a_n5109_n1805# a_n5135_n1747# w_n5257_n1943# a_n5109_n147#
X0 a_n5109_n147# a_n5135_n1747# a_n5109_n1805# w_n5257_n1943# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X3$1 a_n5022_n1696# a_n5022_n38# a_n5196_n1798# a_n5110_n1638#
X0 a_n5022_n38# a_n5110_n1638# a_n5022_n1696# a_n5196_n1798# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X6$1 a_n7694_n2470# a_n7694_n4128# a_n7868_n4230# a_n7782_n4070#
X0 a_n7694_n2470# a_n7782_n4070# a_n7694_n4128# a_n7868_n4230# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X2$1 a_n5254_n1836# a_n5168_n1676# a_n5080_n1734# a_n5080_n76#
X0 a_n5080_n76# a_n5168_n1676# a_n5080_n1734# a_n5254_n1836# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X5$1 a_n5018_n1474# a_n5018_184# a_n5192_n1576# a_n5106_n1416#
X0 a_n5018_184# a_n5106_n1416# a_n5018_n1474# a_n5192_n1576# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt pseudo_resistor_s8 m1_n9031_390# m1_n8431_n2433# m1_n8949_n1612# m1_n8379_n214#
+ m1_n8990_n2564# m1_n8466_31# m1_n8950_n337# VSUBS
XX1$1_0 m1_n9031_390# m1_n9031_390# m1_n7863_n1622# m1_n8950_n337# X1$1
XX4$1_0 VSUBS VSUBS m1_n8379_n214# m1_n8431_n2433# X4$1
XX7$1_0 VSUBS m1_n8990_n2564# m1_n8950_n337# VSUBS X7$1
XX0$1_0 m1_n7863_n1622# m1_n8379_n214# m1_n8466_31# m1_n8466_31# X0$1
XX3$1_0 m1_n8949_n1612# m1_n8950_n337# VSUBS m1_n9031_390# X3$1
XX6$1_0 VSUBS m1_n8950_n337# VSUBS m1_n8431_n2433# X6$1
XX2$1_0 VSUBS m1_n8466_31# m1_n8949_n1612# m1_n8379_n214# X2$1
XX5$1_0 m1_n8379_n214# VSUBS VSUBS m1_n8990_n2564# X5$1
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_AWGYQ2$1 c1_n5265_n5346# m3_n5365_n5446# m3_230_n5446#
+ c1_330_n5346#
X0 c1_n5265_n5346# m3_n5365_n5446# sky130_fd_pr__cap_mim_m3_1 l=2.528e+07u w=2.528e+07u
X1 c1_330_n5346# m3_230_n5446# sky130_fd_pr__cap_mim_m3_1 l=2.528e+07u w=2.528e+07u
X2 c1_330_n5346# m3_230_n5446# sky130_fd_pr__cap_mim_m3_1 l=2.528e+07u w=2.528e+07u
X3 c1_n5265_n5346# m3_n5365_n5446# sky130_fd_pr__cap_mim_m3_1 l=2.528e+07u w=2.528e+07u
.ends

.subckt x5p_capacitor$1 sky130_fd_pr__cap_mim_m3_1_AWGYQ2$1_0/c1_n5265_n5346# sky130_fd_pr__cap_mim_m3_1_AWGYQ2$1_0/m3_230_n5446#
+ sky130_fd_pr__cap_mim_m3_1_AWGYQ2$1_0/m3_n5365_n5446# sky130_fd_pr__cap_mim_m3_1_AWGYQ2$1_0/c1_330_n5346#
Xsky130_fd_pr__cap_mim_m3_1_AWGYQ2$1_0 sky130_fd_pr__cap_mim_m3_1_AWGYQ2$1_0/c1_n5265_n5346#
+ sky130_fd_pr__cap_mim_m3_1_AWGYQ2$1_0/m3_n5365_n5446# sky130_fd_pr__cap_mim_m3_1_AWGYQ2$1_0/m3_230_n5446#
+ sky130_fd_pr__cap_mim_m3_1_AWGYQ2$1_0/c1_330_n5346# sky130_fd_pr__cap_mim_m3_1_AWGYQ2$1
.ends

.subckt sky130_fd_pr__pfet_01v8_589FFS$2 w_n996_n261# a_n800_n139# a_800_n42# a_n858_n42#
X0 a_800_n42# a_n800_n139# a_n858_n42# w_n996_n261# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt x042w8l_pmos$2 sky130_fd_pr__pfet_01v8_589FFS$2_0/a_800_n42# sky130_fd_pr__pfet_01v8_589FFS$2_0/w_n996_n261#
+ sky130_fd_pr__pfet_01v8_589FFS$2_0/a_n858_n42# sky130_fd_pr__pfet_01v8_589FFS$2_0/a_n800_n139#
Xsky130_fd_pr__pfet_01v8_589FFS$2_0 sky130_fd_pr__pfet_01v8_589FFS$2_0/w_n996_n261#
+ sky130_fd_pr__pfet_01v8_589FFS$2_0/a_n800_n139# sky130_fd_pr__pfet_01v8_589FFS$2_0/a_800_n42#
+ sky130_fd_pr__pfet_01v8_589FFS$2_0/a_n858_n42# sky130_fd_pr__pfet_01v8_589FFS$2
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_9B94PP$8 c1_n738_n688# m3_n838_n788#
X0 c1_n738_n688# m3_n838_n788# sky130_fd_pr__cap_mim_m3_1 l=6.88e+06u w=6.88e+06u
.ends

.subckt x100f_capacitor$8 sky130_fd_pr__cap_mim_m3_1_9B94PP$8_0/m3_n838_n788# sky130_fd_pr__cap_mim_m3_1_9B94PP$8_0/c1_n738_n688#
Xsky130_fd_pr__cap_mim_m3_1_9B94PP$8_0 sky130_fd_pr__cap_mim_m3_1_9B94PP$8_0/c1_n738_n688#
+ sky130_fd_pr__cap_mim_m3_1_9B94PP$8_0/m3_n838_n788# sky130_fd_pr__cap_mim_m3_1_9B94PP$8
.ends

.subckt OTA_tb_ps8 Vin1 Vin2 Vcasn Vss Vout Vdd Vcontrol2 Vcasp Vbias v1 Vcontrol1
+ v2 VSUBS
X10p_capacitor$2_0 m3_3024_n301# m3_3024_n301# m4_n17596_23877# m4_n17596_23877# m3_3024_n301#
+ m4_n17596_23877# m3_3024_n301# x10p_capacitor$2
X7w1_5l_nmos$1_0 m1_1629_4037# m1_1809_4176# Vout VSUBS x7w1_5l_nmos$1
X024w8l_nmos$6$1_0 VSUBS m1_1629_4037# m1_3248_6136# VSUBS x024w8l_nmos$6$1
X50w042l_nmos$1_0 VSUBS Vbias m1_2970_7585# VSUBS x50w042l_nmos$1
X042w8l_pmos$1$1_0 Vdd m1_3184_1154# Vdd m1_3184_1154# x042w8l_pmos$1$1
X042w042l_pmos$1$1_0 m1_2970_7585# Vdd Vdd m1_3479_7472# x042w042l_pmos$1$1
X7w3_5l_pmos$1_0 m1_1326_3060# Vout Vdd m1_3342_2253# x7w3_5l_pmos$1
X024w8l_nmos$5$1_0 m1_3282_6654# VSUBS m1_3282_6654# VSUBS x024w8l_nmos$5$1
X50w1l_pmos$2_0 m1_3479_7472# m3_3024_n301# Vdd m1_3282_6654# x50w1l_pmos$2
X10p_capacitor$1$1_0 m1_4464_n2543# m4_n17304_11241# m1_4464_n2543# m4_n17304_11241#
+ m1_4464_n2543# m4_n17304_11241# x10p_capacitor$1$1
X042w042l_pmos$2_0 Vdd m1_2970_7585# m1_2970_7585# Vdd x042w042l_pmos$2
X100f_capacitor$1_0 VSUBS m1_4464_n2543# x100f_capacitor$1
Xpads$8_0 Vbias m1_1809_4176# Vcontrol1 m4_n17596_23877# m1_n11185_n27702# pseudo_resistor_s8_0/m1_n8990_n2564#
+ VSUBS Vout m1_3342_2253# v1 m4_n17304_11241# Vdd pads$8
X50w1l_pmos$1$1_0 m1_3479_7472# m1_4464_n2543# m1_3248_6136# Vdd x50w1l_pmos$1$1
X024w8l_nmos$7$1_0 m1_3282_6654# m1_3184_1154# VSUBS VSUBS x024w8l_nmos$7$1
X024w8l_nmos$8_0 VSUBS m1_3248_6136# m1_3248_6136# VSUBS x024w8l_nmos$8
Xpseudo_resistor_s8_0 Vout Vcontrol1 Vdd v1 pseudo_resistor_s8_0/m1_n8990_n2564# m3_3024_n301#
+ m1_n11185_n27702# VSUBS pseudo_resistor_s8
X5p_capacitor$1_0 VSUBS Vout Vout VSUBS x5p_capacitor$1
X042w8l_pmos$2_0 m1_1326_3060# Vdd Vdd m1_3184_1154# x042w8l_pmos$2
X100f_capacitor$8_0 m3_3024_n301# Vout x100f_capacitor$8
.ends

.subckt sky130_fd_pr__nfet_01v8_BP3WK9$6 a_2167_n5338# a_1967_n5426# a_1909_n5338#
+ a_1807_n5512#
X0 a_2167_n5338# a_1967_n5426# a_1909_n5338# a_1807_n5512# sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt x1w1l_nmos$6 sky130_fd_pr__nfet_01v8_BP3WK9$6_0/a_1967_n5426# sky130_fd_pr__nfet_01v8_BP3WK9$6_0/a_1909_n5338#
+ sky130_fd_pr__nfet_01v8_BP3WK9$6_0/a_2167_n5338# VSUBS
Xsky130_fd_pr__nfet_01v8_BP3WK9$6_0 sky130_fd_pr__nfet_01v8_BP3WK9$6_0/a_2167_n5338#
+ sky130_fd_pr__nfet_01v8_BP3WK9$6_0/a_1967_n5426# sky130_fd_pr__nfet_01v8_BP3WK9$6_0/a_1909_n5338#
+ VSUBS sky130_fd_pr__nfet_01v8_BP3WK9$6
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_9B94PP$7 c1_n738_n688# m3_n838_n788#
X0 c1_n738_n688# m3_n838_n788# sky130_fd_pr__cap_mim_m3_1 l=6.88e+06u w=6.88e+06u
.ends

.subckt x100f_capacitor$7 sky130_fd_pr__cap_mim_m3_1_9B94PP$7_0/m3_n838_n788# sky130_fd_pr__cap_mim_m3_1_9B94PP$7_0/c1_n738_n688#
Xsky130_fd_pr__cap_mim_m3_1_9B94PP$7_0 sky130_fd_pr__cap_mim_m3_1_9B94PP$7_0/c1_n738_n688#
+ sky130_fd_pr__cap_mim_m3_1_9B94PP$7_0/m3_n838_n788# sky130_fd_pr__cap_mim_m3_1_9B94PP$7
.ends

.subckt sky130_fd_pr__pfet_01v8_9GKHW3$6 a_n2270_11865# a_n2012_11865# a_n2212_11768#
+ w_n2408_11646#
X0 a_n2012_11865# a_n2212_11768# a_n2270_11865# w_n2408_11646# sky130_fd_pr__pfet_01v8 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
.ends

.subckt x2w1l_pmos$6 sky130_fd_pr__pfet_01v8_9GKHW3$6_0/a_n2012_11865# sky130_fd_pr__pfet_01v8_9GKHW3$6_0/w_n2408_11646#
+ sky130_fd_pr__pfet_01v8_9GKHW3$6_0/a_n2212_11768# sky130_fd_pr__pfet_01v8_9GKHW3$6_0/a_n2270_11865#
Xsky130_fd_pr__pfet_01v8_9GKHW3$6_0 sky130_fd_pr__pfet_01v8_9GKHW3$6_0/a_n2270_11865#
+ sky130_fd_pr__pfet_01v8_9GKHW3$6_0/a_n2012_11865# sky130_fd_pr__pfet_01v8_9GKHW3$6_0/a_n2212_11768#
+ sky130_fd_pr__pfet_01v8_9GKHW3$6_0/w_n2408_11646# sky130_fd_pr__pfet_01v8_9GKHW3$6
.ends

.subckt sky130_fd_pr__res_generic_nd_582NPY$1 a_n1532_n8486# a_1326_n8363# a_n1410_n8363#
X0 a_n1410_n8363# a_1326_n8363# a_n1532_n8486# sky130_fd_pr__res_generic_nd w=420000u l=1.65616e+09u
.ends

.subckt x524k_ndiff_resistor$1 sky130_fd_pr__res_generic_nd_582NPY$1_0/a_n1410_n8363#
+ sky130_fd_pr__res_generic_nd_582NPY$1_0/a_1326_n8363# VSUBS
Xsky130_fd_pr__res_generic_nd_582NPY$1_0 VSUBS sky130_fd_pr__res_generic_nd_582NPY$1_0/a_1326_n8363#
+ sky130_fd_pr__res_generic_nd_582NPY$1_0/a_n1410_n8363# sky130_fd_pr__res_generic_nd_582NPY$1
.ends

.subckt TIA_542k Vdd Vout Iin gnd
X1w1l_nmos$6_0 li_n6552_105# gnd li_n6552_n2631# gnd x1w1l_nmos$6
X100f_capacitor$7_0 li_n6552_n2631# Vout x100f_capacitor$7
X2w1l_pmos$6_0 li_n6552_n2631# Vdd li_n6552_105# Vdd x2w1l_pmos$6
X524k_ndiff_resistor$1_0 li_n6552_105# li_n6552_n2631# gnd x524k_ndiff_resistor$1
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_AWGYQ2 c1_n5265_n5346# m3_n5365_n5446# m3_230_n5446#
+ c1_330_n5346#
X0 c1_n5265_n5346# m3_n5365_n5446# sky130_fd_pr__cap_mim_m3_1 l=2.528e+07u w=2.528e+07u
X1 c1_330_n5346# m3_230_n5446# sky130_fd_pr__cap_mim_m3_1 l=2.528e+07u w=2.528e+07u
X2 c1_330_n5346# m3_230_n5446# sky130_fd_pr__cap_mim_m3_1 l=2.528e+07u w=2.528e+07u
X3 c1_n5265_n5346# m3_n5365_n5446# sky130_fd_pr__cap_mim_m3_1 l=2.528e+07u w=2.528e+07u
.ends

.subckt x5p_capacitor sky130_fd_pr__cap_mim_m3_1_AWGYQ2_0/c1_n5265_n5346# sky130_fd_pr__cap_mim_m3_1_AWGYQ2_0/m3_n5365_n5446#
+ sky130_fd_pr__cap_mim_m3_1_AWGYQ2_0/m3_230_n5446# sky130_fd_pr__cap_mim_m3_1_AWGYQ2_0/c1_330_n5346#
Xsky130_fd_pr__cap_mim_m3_1_AWGYQ2_0 sky130_fd_pr__cap_mim_m3_1_AWGYQ2_0/c1_n5265_n5346#
+ sky130_fd_pr__cap_mim_m3_1_AWGYQ2_0/m3_n5365_n5446# sky130_fd_pr__cap_mim_m3_1_AWGYQ2_0/m3_230_n5446#
+ sky130_fd_pr__cap_mim_m3_1_AWGYQ2_0/c1_330_n5346# sky130_fd_pr__cap_mim_m3_1_AWGYQ2
.ends

.subckt sky130_fd_pr__pfet_01v8_HWZHW3 a_100_n5000# a_n158_n5000# a_n100_n5097# w_n296_n5219#
X0 a_100_n5000# a_n100_n5097# a_n158_n5000# w_n296_n5219# sky130_fd_pr__pfet_01v8 ad=1.45e+13p pd=1.0058e+08u as=1.45e+13p ps=1.0058e+08u w=5e+07u l=1e+06u
.ends

.subckt x50w1l_pmos sky130_fd_pr__pfet_01v8_HWZHW3_0/a_n100_n5097# sky130_fd_pr__pfet_01v8_HWZHW3_0/w_n296_n5219#
+ sky130_fd_pr__pfet_01v8_HWZHW3_0/a_100_n5000# sky130_fd_pr__pfet_01v8_HWZHW3_0/a_n158_n5000#
Xsky130_fd_pr__pfet_01v8_HWZHW3_0 sky130_fd_pr__pfet_01v8_HWZHW3_0/a_100_n5000# sky130_fd_pr__pfet_01v8_HWZHW3_0/a_n158_n5000#
+ sky130_fd_pr__pfet_01v8_HWZHW3_0/a_n100_n5097# sky130_fd_pr__pfet_01v8_HWZHW3_0/w_n296_n5219#
+ sky130_fd_pr__pfet_01v8_HWZHW3
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_9B94PP$6 c1_n738_n688# m3_n838_n788#
X0 c1_n738_n688# m3_n838_n788# sky130_fd_pr__cap_mim_m3_1 l=6.88e+06u w=6.88e+06u
.ends

.subckt x100f_capacitor$6 sky130_fd_pr__cap_mim_m3_1_9B94PP$6_0/c1_n738_n688# sky130_fd_pr__cap_mim_m3_1_9B94PP$6_0/m3_n838_n788#
Xsky130_fd_pr__cap_mim_m3_1_9B94PP$6_0 sky130_fd_pr__cap_mim_m3_1_9B94PP$6_0/c1_n738_n688#
+ sky130_fd_pr__cap_mim_m3_1_9B94PP$6_0/m3_n838_n788# sky130_fd_pr__cap_mim_m3_1_9B94PP$6
.ends

.subckt sky130_fd_pr__nfet_01v8_6BSMN9 a_800_n42# a_n960_n216# a_n858_n42# a_n800_n130#
X0 a_800_n42# a_n800_n130# a_n858_n42# a_n960_n216# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt x024w8l_nmos sky130_fd_pr__nfet_01v8_6BSMN9_0/a_n858_n42# sky130_fd_pr__nfet_01v8_6BSMN9_0/a_800_n42#
+ sky130_fd_pr__nfet_01v8_6BSMN9_0/a_n800_n130# VSUBS
Xsky130_fd_pr__nfet_01v8_6BSMN9_0 sky130_fd_pr__nfet_01v8_6BSMN9_0/a_800_n42# VSUBS
+ sky130_fd_pr__nfet_01v8_6BSMN9_0/a_n858_n42# sky130_fd_pr__nfet_01v8_6BSMN9_0/a_n800_n130#
+ sky130_fd_pr__nfet_01v8_6BSMN9
.ends

.subckt sky130_fd_pr__pfet_01v8_HWZHW3$1 a_100_n5000# a_n158_n5000# a_n100_n5097#
+ w_n296_n5219#
X0 a_100_n5000# a_n100_n5097# a_n158_n5000# w_n296_n5219# sky130_fd_pr__pfet_01v8 ad=1.45e+13p pd=1.0058e+08u as=1.45e+13p ps=1.0058e+08u w=5e+07u l=1e+06u
.ends

.subckt x50w1l_pmos$1 sky130_fd_pr__pfet_01v8_HWZHW3$1_0/a_n158_n5000# sky130_fd_pr__pfet_01v8_HWZHW3$1_0/a_100_n5000#
+ sky130_fd_pr__pfet_01v8_HWZHW3$1_0/a_n100_n5097# sky130_fd_pr__pfet_01v8_HWZHW3$1_0/w_n296_n5219#
Xsky130_fd_pr__pfet_01v8_HWZHW3$1_0 sky130_fd_pr__pfet_01v8_HWZHW3$1_0/a_100_n5000#
+ sky130_fd_pr__pfet_01v8_HWZHW3$1_0/a_n158_n5000# sky130_fd_pr__pfet_01v8_HWZHW3$1_0/a_n100_n5097#
+ sky130_fd_pr__pfet_01v8_HWZHW3$1_0/w_n296_n5219# sky130_fd_pr__pfet_01v8_HWZHW3$1
.ends

.subckt sky130_fd_pr__nfet_01v8_ZEJXTR a_42_n5000# a_n202_n5174# a_n42_n5088# a_n100_n5000#
X0 a_42_n5000# a_n42_n5088# a_n100_n5000# a_n202_n5174# sky130_fd_pr__nfet_01v8 ad=1.45e+13p pd=1.0058e+08u as=1.45e+13p ps=1.0058e+08u w=5e+07u l=420000u
.ends

.subckt x50w042l_nmos sky130_fd_pr__nfet_01v8_ZEJXTR_0/a_42_n5000# sky130_fd_pr__nfet_01v8_ZEJXTR_0/a_n42_n5088#
+ sky130_fd_pr__nfet_01v8_ZEJXTR_0/a_n100_n5000# VSUBS
Xsky130_fd_pr__nfet_01v8_ZEJXTR_0 sky130_fd_pr__nfet_01v8_ZEJXTR_0/a_42_n5000# VSUBS
+ sky130_fd_pr__nfet_01v8_ZEJXTR_0/a_n42_n5088# sky130_fd_pr__nfet_01v8_ZEJXTR_0/a_n100_n5000#
+ sky130_fd_pr__nfet_01v8_ZEJXTR
.ends

.subckt sky130_fd_pr__pfet_01v8_GJQV38 w_n546_n919# a_n350_n797# a_350_n700# a_n408_n700#
X0 a_350_n700# a_n350_n797# a_n408_n700# w_n546_n919# sky130_fd_pr__pfet_01v8 ad=2.03e+12p pd=1.458e+07u as=2.03e+12p ps=1.458e+07u w=7e+06u l=3.5e+06u
.ends

.subckt x7w3_5l_pmos sky130_fd_pr__pfet_01v8_GJQV38_0/a_350_n700# sky130_fd_pr__pfet_01v8_GJQV38_0/w_n546_n919#
+ sky130_fd_pr__pfet_01v8_GJQV38_0/a_n350_n797# sky130_fd_pr__pfet_01v8_GJQV38_0/a_n408_n700#
Xsky130_fd_pr__pfet_01v8_GJQV38_0 sky130_fd_pr__pfet_01v8_GJQV38_0/w_n546_n919# sky130_fd_pr__pfet_01v8_GJQV38_0/a_n350_n797#
+ sky130_fd_pr__pfet_01v8_GJQV38_0/a_350_n700# sky130_fd_pr__pfet_01v8_GJQV38_0/a_n408_n700#
+ sky130_fd_pr__pfet_01v8_GJQV38
.ends

.subckt sky130_fd_pr__pfet_01v8_U2PZU3$1 w_n238_n261# a_n100_n42# a_n42_n139# a_42_n42#
X0 a_42_n42# a_n42_n139# a_n100_n42# w_n238_n261# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=420000u
.ends

.subckt x042w042l_pmos$1 sky130_fd_pr__pfet_01v8_U2PZU3$1_0/a_n100_n42# sky130_fd_pr__pfet_01v8_U2PZU3$1_0/a_n42_n139#
+ sky130_fd_pr__pfet_01v8_U2PZU3$1_0/w_n238_n261# sky130_fd_pr__pfet_01v8_U2PZU3$1_0/a_42_n42#
Xsky130_fd_pr__pfet_01v8_U2PZU3$1_0 sky130_fd_pr__pfet_01v8_U2PZU3$1_0/w_n238_n261#
+ sky130_fd_pr__pfet_01v8_U2PZU3$1_0/a_n100_n42# sky130_fd_pr__pfet_01v8_U2PZU3$1_0/a_n42_n139#
+ sky130_fd_pr__pfet_01v8_U2PZU3$1_0/a_42_n42# sky130_fd_pr__pfet_01v8_U2PZU3$1
.ends

.subckt sky130_fd_pr__nfet_01v8_28DC9G a_n150_n788# a_n310_n874# a_150_n700# a_n208_n700#
X0 a_150_n700# a_n150_n788# a_n208_n700# a_n310_n874# sky130_fd_pr__nfet_01v8 ad=2.03e+12p pd=1.458e+07u as=2.03e+12p ps=1.458e+07u w=7e+06u l=1.5e+06u
.ends

.subckt x7w1_5l_nmos sky130_fd_pr__nfet_01v8_28DC9G_0/a_n208_n700# sky130_fd_pr__nfet_01v8_28DC9G_0/a_n150_n788#
+ VSUBS sky130_fd_pr__nfet_01v8_28DC9G_0/a_150_n700#
Xsky130_fd_pr__nfet_01v8_28DC9G_0 sky130_fd_pr__nfet_01v8_28DC9G_0/a_n150_n788# VSUBS
+ sky130_fd_pr__nfet_01v8_28DC9G_0/a_150_n700# sky130_fd_pr__nfet_01v8_28DC9G_0/a_n208_n700#
+ sky130_fd_pr__nfet_01v8_28DC9G
.ends

.subckt sky130_fd_pr__pfet_01v8_DUAJW3$1 w_n296_n319# a_n100_n197# a_100_n100# a_n158_n100#
X0 a_100_n100# a_n100_n197# a_n158_n100# w_n296_n319# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt x1w1l_pmos$1 sky130_fd_pr__pfet_01v8_DUAJW3$1_0/a_n158_n100# sky130_fd_pr__pfet_01v8_DUAJW3$1_0/a_100_n100#
+ sky130_fd_pr__pfet_01v8_DUAJW3$1_0/w_n296_n319# sky130_fd_pr__pfet_01v8_DUAJW3$1_0/a_n100_n197#
Xsky130_fd_pr__pfet_01v8_DUAJW3$1_0 sky130_fd_pr__pfet_01v8_DUAJW3$1_0/w_n296_n319#
+ sky130_fd_pr__pfet_01v8_DUAJW3$1_0/a_n100_n197# sky130_fd_pr__pfet_01v8_DUAJW3$1_0/a_100_n100#
+ sky130_fd_pr__pfet_01v8_DUAJW3$1_0/a_n158_n100# sky130_fd_pr__pfet_01v8_DUAJW3$1
.ends

.subckt sky130_fd_pr__nfet_01v8_6BSMN9$7 a_800_n42# a_n960_n216# a_n858_n42# a_n800_n130#
X0 a_800_n42# a_n800_n130# a_n858_n42# a_n960_n216# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt x024w8l_nmos$7 sky130_fd_pr__nfet_01v8_6BSMN9$7_0/a_800_n42# sky130_fd_pr__nfet_01v8_6BSMN9$7_0/a_n858_n42#
+ sky130_fd_pr__nfet_01v8_6BSMN9$7_0/a_n800_n130# VSUBS
Xsky130_fd_pr__nfet_01v8_6BSMN9$7_0 sky130_fd_pr__nfet_01v8_6BSMN9$7_0/a_800_n42#
+ VSUBS sky130_fd_pr__nfet_01v8_6BSMN9$7_0/a_n858_n42# sky130_fd_pr__nfet_01v8_6BSMN9$7_0/a_n800_n130#
+ sky130_fd_pr__nfet_01v8_6BSMN9$7
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_9B94PP$1$1 c1_n738_n928# m3_n838_n1028#
X0 c1_n738_n928# m3_n838_n1028# sky130_fd_pr__cap_mim_m3_1 l=6.88e+06u w=6.88e+06u
.ends

.subckt x100f_capacitor$1$1 sky130_fd_pr__cap_mim_m3_1_9B94PP$1$1_0/c1_n738_n928#
+ sky130_fd_pr__cap_mim_m3_1_9B94PP$1$1_0/m3_n838_n1028#
Xsky130_fd_pr__cap_mim_m3_1_9B94PP$1$1_0 sky130_fd_pr__cap_mim_m3_1_9B94PP$1$1_0/c1_n738_n928#
+ sky130_fd_pr__cap_mim_m3_1_9B94PP$1$1_0/m3_n838_n1028# sky130_fd_pr__cap_mim_m3_1_9B94PP$1$1
.ends

.subckt sky130_fd_pr__pfet_01v8_589FFS$1 w_n996_n261# a_n800_n139# a_800_n42# a_n858_n42#
X0 a_800_n42# a_n800_n139# a_n858_n42# w_n996_n261# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt x042w8l_pmos$1 sky130_fd_pr__pfet_01v8_589FFS$1_0/a_n858_n42# sky130_fd_pr__pfet_01v8_589FFS$1_0/w_n996_n261#
+ sky130_fd_pr__pfet_01v8_589FFS$1_0/a_n800_n139# sky130_fd_pr__pfet_01v8_589FFS$1_0/a_800_n42#
Xsky130_fd_pr__pfet_01v8_589FFS$1_0 sky130_fd_pr__pfet_01v8_589FFS$1_0/w_n996_n261#
+ sky130_fd_pr__pfet_01v8_589FFS$1_0/a_n800_n139# sky130_fd_pr__pfet_01v8_589FFS$1_0/a_800_n42#
+ sky130_fd_pr__pfet_01v8_589FFS$1_0/a_n858_n42# sky130_fd_pr__pfet_01v8_589FFS$1
.ends

.subckt sky130_fd_pr__nfet_01v8_6BSMN9$5 a_800_n42# a_n960_n216# a_n858_n42# a_n800_n130#
X0 a_800_n42# a_n800_n130# a_n858_n42# a_n960_n216# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt x024w8l_nmos$5 sky130_fd_pr__nfet_01v8_6BSMN9$5_0/a_n858_n42# sky130_fd_pr__nfet_01v8_6BSMN9$5_0/a_800_n42#
+ sky130_fd_pr__nfet_01v8_6BSMN9$5_0/a_n800_n130# VSUBS
Xsky130_fd_pr__nfet_01v8_6BSMN9$5_0 sky130_fd_pr__nfet_01v8_6BSMN9$5_0/a_800_n42#
+ VSUBS sky130_fd_pr__nfet_01v8_6BSMN9$5_0/a_n858_n42# sky130_fd_pr__nfet_01v8_6BSMN9$5_0/a_n800_n130#
+ sky130_fd_pr__nfet_01v8_6BSMN9$5
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_8NU5HM$1 c1_n2155_n7555# m3_n7444_n7655# m3_n2255_n7655#
+ c1_3034_n7555# m3_2934_n7655# c1_n7344_n7555#
X0 c1_n7344_n7555# m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X1 c1_n2155_n7555# m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X2 c1_n7344_n7555# m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X3 c1_n2155_n7555# m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X4 c1_3034_n7555# m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X5 c1_3034_n7555# m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X6 c1_n2155_n7555# m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X7 c1_3034_n7555# m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X8 c1_n7344_n7555# m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
.ends

.subckt x10p_capacitor$1 sky130_fd_pr__cap_mim_m3_1_8NU5HM$1_0/m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1_8NU5HM$1_0/m3_n7444_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$1_0/c1_n2155_n7555# sky130_fd_pr__cap_mim_m3_1_8NU5HM$1_0/m3_n2255_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$1_0/c1_n7344_n7555# sky130_fd_pr__cap_mim_m3_1_8NU5HM$1_0/c1_3034_n7555#
Xsky130_fd_pr__cap_mim_m3_1_8NU5HM$1_0 sky130_fd_pr__cap_mim_m3_1_8NU5HM$1_0/c1_n2155_n7555#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$1_0/m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1_8NU5HM$1_0/m3_n2255_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$1_0/c1_3034_n7555# sky130_fd_pr__cap_mim_m3_1_8NU5HM$1_0/m3_2934_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$1_0/c1_n7344_n7555# sky130_fd_pr__cap_mim_m3_1_8NU5HM$1
.ends

.subckt sky130_fd_pr__pfet_01v8_U2PZU3 w_n238_n261# a_n100_n42# a_n42_n139# a_42_n42#
X0 a_42_n42# a_n42_n139# a_n100_n42# w_n238_n261# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=420000u
.ends

.subckt x042w042l_pmos sky130_fd_pr__pfet_01v8_U2PZU3_0/a_n100_n42# sky130_fd_pr__pfet_01v8_U2PZU3_0/a_n42_n139#
+ sky130_fd_pr__pfet_01v8_U2PZU3_0/a_42_n42# sky130_fd_pr__pfet_01v8_U2PZU3_0/w_n238_n261#
Xsky130_fd_pr__pfet_01v8_U2PZU3_0 sky130_fd_pr__pfet_01v8_U2PZU3_0/w_n238_n261# sky130_fd_pr__pfet_01v8_U2PZU3_0/a_n100_n42#
+ sky130_fd_pr__pfet_01v8_U2PZU3_0/a_n42_n139# sky130_fd_pr__pfet_01v8_U2PZU3_0/a_42_n42#
+ sky130_fd_pr__pfet_01v8_U2PZU3
.ends

.subckt sky130_fd_pr__pfet_01v8_DUAJW3 w_n296_n319# a_n100_n197# a_100_n100# a_n158_n100#
X0 a_100_n100# a_n100_n197# a_n158_n100# w_n296_n319# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt x1w1l_pmos sky130_fd_pr__pfet_01v8_DUAJW3_0/a_n158_n100# sky130_fd_pr__pfet_01v8_DUAJW3_0/a_100_n100#
+ sky130_fd_pr__pfet_01v8_DUAJW3_0/w_n296_n319# sky130_fd_pr__pfet_01v8_DUAJW3_0/a_n100_n197#
Xsky130_fd_pr__pfet_01v8_DUAJW3_0 sky130_fd_pr__pfet_01v8_DUAJW3_0/w_n296_n319# sky130_fd_pr__pfet_01v8_DUAJW3_0/a_n100_n197#
+ sky130_fd_pr__pfet_01v8_DUAJW3_0/a_100_n100# sky130_fd_pr__pfet_01v8_DUAJW3_0/a_n158_n100#
+ sky130_fd_pr__pfet_01v8_DUAJW3
.ends

.subckt sky130_fd_pr__pfet_01v8_589FFS w_n996_n261# a_n800_n139# a_800_n42# a_n858_n42#
X0 a_800_n42# a_n800_n139# a_n858_n42# w_n996_n261# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt x042w8l_pmos sky130_fd_pr__pfet_01v8_589FFS_0/w_n996_n261# sky130_fd_pr__pfet_01v8_589FFS_0/a_n800_n139#
+ sky130_fd_pr__pfet_01v8_589FFS_0/a_800_n42# sky130_fd_pr__pfet_01v8_589FFS_0/a_n858_n42#
Xsky130_fd_pr__pfet_01v8_589FFS_0 sky130_fd_pr__pfet_01v8_589FFS_0/w_n996_n261# sky130_fd_pr__pfet_01v8_589FFS_0/a_n800_n139#
+ sky130_fd_pr__pfet_01v8_589FFS_0/a_800_n42# sky130_fd_pr__pfet_01v8_589FFS_0/a_n858_n42#
+ sky130_fd_pr__pfet_01v8_589FFS
.ends

.subckt pads$6 single_pad$1_0[1|2]/m1_n12006_n4000# single_pad$1_0[1|4]/b_n11776_n3760#
+ single_pad$1_0[0|1]/b_n11776_n3760# single_pad$1_0[0|2]/m1_n12006_n4000# single_pad$1_0[1|4]/m1_n12006_n4000#
+ single_pad$1_0[1|1]/b_n11776_n3760# single_pad$1_0[0|3]/b_n11776_n3760# single_pad$1_0[1|1]/m1_n12006_n4000#
+ single_pad$1_0[0|4]/m1_n12006_n4000# single_pad$1_0[1|3]/b_n11776_n3760# single_pad$1_0[0|0]/b_n11776_n3760#
+ single_pad$1_0[0|1]/m1_n12006_n4000# single_pad$1_0[1|3]/m1_n12006_n4000# single_pad$1_0[1|0]/b_n11776_n3760#
+ single_pad$1_0[0|2]/b_n11776_n3760# single_pad$1_0[1|0]/m1_n12006_n4000# single_pad$1_0[0|3]/m1_n12006_n4000#
+ single_pad$1_0[1|2]/b_n11776_n3760# single_pad$1_0[0|4]/b_n11776_n3760# single_pad$1_0[0|0]/m1_n12006_n4000#
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_8NU5HM c1_n2155_n7555# m3_n7444_n7655# m3_n2255_n7655#
+ c1_3034_n7555# m3_2934_n7655# c1_n7344_n7555#
X0 c1_n7344_n7555# m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X1 c1_n2155_n7555# m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X2 c1_n7344_n7555# m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X3 c1_n2155_n7555# m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X4 c1_3034_n7555# m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X5 c1_3034_n7555# m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X6 c1_n2155_n7555# m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X7 c1_3034_n7555# m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X8 c1_n7344_n7555# m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
.ends

.subckt x10p_capacitor sky130_fd_pr__cap_mim_m3_1_8NU5HM_0/m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1_8NU5HM_0/c1_n7344_n7555#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM_0/c1_3034_n7555# sky130_fd_pr__cap_mim_m3_1_8NU5HM_0/m3_2934_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM_0/m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1_8NU5HM_0/c1_n2155_n7555#
Xsky130_fd_pr__cap_mim_m3_1_8NU5HM_0 sky130_fd_pr__cap_mim_m3_1_8NU5HM_0/c1_n2155_n7555#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM_0/m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1_8NU5HM_0/m3_n2255_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM_0/c1_3034_n7555# sky130_fd_pr__cap_mim_m3_1_8NU5HM_0/m3_2934_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM_0/c1_n7344_n7555# sky130_fd_pr__cap_mim_m3_1_8NU5HM
.ends

.subckt sky130_fd_pr__nfet_01v8_6BSMN9$6 a_800_n42# a_n960_n216# a_n858_n42# a_n800_n130#
X0 a_800_n42# a_n800_n130# a_n858_n42# a_n960_n216# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt x024w8l_nmos$6 sky130_fd_pr__nfet_01v8_6BSMN9$6_0/a_800_n42# sky130_fd_pr__nfet_01v8_6BSMN9$6_0/a_n858_n42#
+ VSUBS sky130_fd_pr__nfet_01v8_6BSMN9$6_0/a_n800_n130#
Xsky130_fd_pr__nfet_01v8_6BSMN9$6_0 sky130_fd_pr__nfet_01v8_6BSMN9$6_0/a_800_n42#
+ VSUBS sky130_fd_pr__nfet_01v8_6BSMN9$6_0/a_n858_n42# sky130_fd_pr__nfet_01v8_6BSMN9$6_0/a_n800_n130#
+ sky130_fd_pr__nfet_01v8_6BSMN9$6
.ends

.subckt OTA_tb Vin1 Vin2 Vcasn Vss Vb1 Vcasp Vbias pads$6_0/single_pad$1_0[1|3]/b_n11776_n3760#
+ pads$6_0/single_pad$1_0[0|0]/b_n11776_n3760# pads$6_0/single_pad$1_0[1|0]/b_n11776_n3760#
+ pads$6_0/single_pad$1_0[0|2]/b_n11776_n3760# m1_1326_3060# m1_1809_4176# pads$6_0/single_pad$1_0[1|2]/b_n11776_n3760#
+ pads$6_0/single_pad$1_0[0|4]/b_n11776_n3760# pads$6_0/single_pad$1_0[1|4]/b_n11776_n3760#
+ m1_3248_6136# m1_3342_2253# pads$6_0/single_pad$1_0[0|1]/b_n11776_n3760# m1_1822_150#
+ m1_3479_7472# pads$6_0/single_pad$1_0[0|4]/m1_n12006_n4000# m1_1629_4037# m1_4464_n2543#
+ m1_3184_1154# m4_n17596_23877# Vdd pads$6_0/single_pad$1_0[1|1]/b_n11776_n3760#
+ m1_3282_6654# m1_2970_7585# m1_1450_152# Vout m4_n17304_11241# VSUBS m1_1693_316#
+ pads$6_0/single_pad$1_0[0|3]/b_n11776_n3760#
X5p_capacitor_0 VSUBS Vout Vout VSUBS x5p_capacitor
X50w1l_pmos_0 m1_1450_152# Vdd m1_3282_6654# m1_3479_7472# x50w1l_pmos
X100f_capacitor$6_0 Vout m1_1450_152# x100f_capacitor$6
X024w8l_nmos_0 VSUBS m1_3248_6136# m1_3248_6136# VSUBS x024w8l_nmos
X50w1l_pmos$1_0 m1_3479_7472# m1_3248_6136# m1_4464_n2543# Vdd x50w1l_pmos$1
X50w042l_nmos_0 m1_2970_7585# Vbias VSUBS VSUBS x50w042l_nmos
X7w3_5l_pmos_0 Vout Vdd m1_3342_2253# m1_1326_3060# x7w3_5l_pmos
X042w042l_pmos$1_0 Vdd m1_2970_7585# Vdd m1_3479_7472# x042w042l_pmos$1
X7w1_5l_nmos_0 m1_1629_4037# m1_1809_4176# VSUBS Vout x7w1_5l_nmos
X1w1l_pmos$1_0 Vout m1_1822_150# Vout m1_1693_316# x1w1l_pmos$1
X024w8l_nmos$7_0 m1_3184_1154# VSUBS m1_3282_6654# VSUBS x024w8l_nmos$7
X100f_capacitor$1$1_0 m1_4464_n2543# VSUBS x100f_capacitor$1$1
X042w8l_pmos$1_0 Vdd Vdd m1_3184_1154# m1_3184_1154# x042w8l_pmos$1
X024w8l_nmos$5_0 VSUBS m1_3282_6654# m1_3282_6654# VSUBS x024w8l_nmos$5
X10p_capacitor$1_0 m1_4464_n2543# m1_4464_n2543# m4_n17304_11241# m1_4464_n2543# m4_n17304_11241#
+ m4_n17304_11241# x10p_capacitor$1
X042w042l_pmos_0 Vdd m1_2970_7585# m1_2970_7585# Vdd x042w042l_pmos
X1w1l_pmos_0 m1_1450_152# m1_1822_150# m1_1450_152# m1_1693_316# x1w1l_pmos
X042w8l_pmos_0 Vdd m1_3184_1154# m1_1326_3060# Vdd x042w8l_pmos
Xpads$6_0 m1_1693_316# pads$6_0/single_pad$1_0[1|4]/b_n11776_n3760# pads$6_0/single_pad$1_0[0|1]/b_n11776_n3760#
+ VSUBS Vout pads$6_0/single_pad$1_0[1|1]/b_n11776_n3760# pads$6_0/single_pad$1_0[0|3]/b_n11776_n3760#
+ m1_3342_2253# pads$6_0/single_pad$1_0[0|4]/m1_n12006_n4000# pads$6_0/single_pad$1_0[1|3]/b_n11776_n3760#
+ pads$6_0/single_pad$1_0[0|0]/b_n11776_n3760# m4_n17304_11241# Vdd pads$6_0/single_pad$1_0[1|0]/b_n11776_n3760#
+ pads$6_0/single_pad$1_0[0|2]/b_n11776_n3760# Vbias m1_1809_4176# pads$6_0/single_pad$1_0[1|2]/b_n11776_n3760#
+ pads$6_0/single_pad$1_0[0|4]/b_n11776_n3760# m4_n17596_23877# pads$6
X10p_capacitor_0 m1_1450_152# m4_n17596_23877# m4_n17596_23877# m1_1450_152# m1_1450_152#
+ m4_n17596_23877# x10p_capacitor
X024w8l_nmos$6_0 m1_1629_4037# VSUBS VSUBS m1_3248_6136# x024w8l_nmos$6
.ends

.subckt sky130_fd_pr__pfet_01v8_HWZHW3$3 a_100_n5000# a_n158_n5000# a_n100_n5097#
+ w_n296_n5219#
X0 a_100_n5000# a_n100_n5097# a_n158_n5000# w_n296_n5219# sky130_fd_pr__pfet_01v8 ad=1.45e+13p pd=1.0058e+08u as=1.45e+13p ps=1.0058e+08u w=5e+07u l=1e+06u
.ends

.subckt x50w1l_pmos$3 sky130_fd_pr__pfet_01v8_HWZHW3$3_0/a_n100_n5097# sky130_fd_pr__pfet_01v8_HWZHW3$3_0/w_n296_n5219#
+ sky130_fd_pr__pfet_01v8_HWZHW3$3_0/a_100_n5000# sky130_fd_pr__pfet_01v8_HWZHW3$3_0/a_n158_n5000#
Xsky130_fd_pr__pfet_01v8_HWZHW3$3_0 sky130_fd_pr__pfet_01v8_HWZHW3$3_0/a_100_n5000#
+ sky130_fd_pr__pfet_01v8_HWZHW3$3_0/a_n158_n5000# sky130_fd_pr__pfet_01v8_HWZHW3$3_0/a_n100_n5097#
+ sky130_fd_pr__pfet_01v8_HWZHW3$3_0/w_n296_n5219# sky130_fd_pr__pfet_01v8_HWZHW3$3
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$2 c1_n2155_n7555# m3_n7444_n7655# m3_n2255_n7655#
+ c1_3034_n7555# m3_2934_n7655# c1_n7344_n7555#
X0 c1_n7344_n7555# m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X1 c1_n2155_n7555# m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X2 c1_n7344_n7555# m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X3 c1_n2155_n7555# m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X4 c1_3034_n7555# m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X5 c1_3034_n7555# m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X6 c1_n2155_n7555# m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X7 c1_3034_n7555# m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X8 c1_n7344_n7555# m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
.ends

.subckt x10p_capacitor$1$2 sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$2_0/m3_2934_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$2_0/c1_n7344_n7555# sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$2_0/c1_n2155_n7555#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$2_0/m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$2_0/m3_n2255_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$2_0/c1_3034_n7555#
Xsky130_fd_pr__cap_mim_m3_1_8NU5HM$1$2_0 sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$2_0/c1_n2155_n7555#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$2_0/m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$2_0/m3_n2255_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$2_0/c1_3034_n7555# sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$2_0/m3_2934_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$2_0/c1_n7344_n7555# sky130_fd_pr__cap_mim_m3_1_8NU5HM$1$2
.ends

.subckt sky130_fd_pr__pfet_01v8_U2PZU3$3 w_n238_n261# a_n100_n42# a_n42_n139# a_42_n42#
X0 a_42_n42# a_n42_n139# a_n100_n42# w_n238_n261# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=420000u
.ends

.subckt x042w042l_pmos$3 sky130_fd_pr__pfet_01v8_U2PZU3$3_0/w_n238_n261# sky130_fd_pr__pfet_01v8_U2PZU3$3_0/a_n100_n42#
+ sky130_fd_pr__pfet_01v8_U2PZU3$3_0/a_n42_n139# sky130_fd_pr__pfet_01v8_U2PZU3$3_0/a_42_n42#
Xsky130_fd_pr__pfet_01v8_U2PZU3$3_0 sky130_fd_pr__pfet_01v8_U2PZU3$3_0/w_n238_n261#
+ sky130_fd_pr__pfet_01v8_U2PZU3$3_0/a_n100_n42# sky130_fd_pr__pfet_01v8_U2PZU3$3_0/a_n42_n139#
+ sky130_fd_pr__pfet_01v8_U2PZU3$3_0/a_42_n42# sky130_fd_pr__pfet_01v8_U2PZU3$3
.ends

.subckt pads$9 single_pad$3_0[0|1]/m1_n12006_n4000# single_pad$3_0[1|3]/m1_n12006_n4000#
+ single_pad$3_0[1|0]/m1_n12006_n4000# single_pad$3_0[0|3]/m1_n12006_n4000# single_pad$3_0[1|5]/m1_n12006_n4000#
+ single_pad$3_0[0|0]/m1_n12006_n4000# single_pad$3_0[0|5]/m1_n12006_n4000# single_pad$3_0[0|2]/m1_n12006_n4000#
+ single_pad$3_0[1|4]/m1_n12006_n4000# single_pad$3_0[1|1]/m1_n12006_n4000# single_pad$3_0[0|4]/m1_n12006_n4000#
.ends

.subckt sky130_fd_pr__pfet_01v8_HWZHW3$1$2 a_100_n5000# a_n158_n5000# a_n100_n5097#
+ w_n296_n5219#
X0 a_100_n5000# a_n100_n5097# a_n158_n5000# w_n296_n5219# sky130_fd_pr__pfet_01v8 ad=1.45e+13p pd=1.0058e+08u as=1.45e+13p ps=1.0058e+08u w=5e+07u l=1e+06u
.ends

.subckt x50w1l_pmos$1$2 sky130_fd_pr__pfet_01v8_HWZHW3$1$2_0/a_100_n5000# sky130_fd_pr__pfet_01v8_HWZHW3$1$2_0/a_n158_n5000#
+ sky130_fd_pr__pfet_01v8_HWZHW3$1$2_0/a_n100_n5097# sky130_fd_pr__pfet_01v8_HWZHW3$1$2_0/w_n296_n5219#
Xsky130_fd_pr__pfet_01v8_HWZHW3$1$2_0 sky130_fd_pr__pfet_01v8_HWZHW3$1$2_0/a_100_n5000#
+ sky130_fd_pr__pfet_01v8_HWZHW3$1$2_0/a_n158_n5000# sky130_fd_pr__pfet_01v8_HWZHW3$1$2_0/a_n100_n5097#
+ sky130_fd_pr__pfet_01v8_HWZHW3$1$2_0/w_n296_n5219# sky130_fd_pr__pfet_01v8_HWZHW3$1$2
.ends

.subckt sky130_fd_pr__nfet_01v8_6BSMN9$7$2 a_800_n42# a_n960_n216# a_n858_n42# a_n800_n130#
X0 a_800_n42# a_n800_n130# a_n858_n42# a_n960_n216# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt x024w8l_nmos$7$2 sky130_fd_pr__nfet_01v8_6BSMN9$7$2_0/a_n858_n42# sky130_fd_pr__nfet_01v8_6BSMN9$7$2_0/a_800_n42#
+ sky130_fd_pr__nfet_01v8_6BSMN9$7$2_0/a_n800_n130# VSUBS
Xsky130_fd_pr__nfet_01v8_6BSMN9$7$2_0 sky130_fd_pr__nfet_01v8_6BSMN9$7$2_0/a_800_n42#
+ VSUBS sky130_fd_pr__nfet_01v8_6BSMN9$7$2_0/a_n858_n42# sky130_fd_pr__nfet_01v8_6BSMN9$7$2_0/a_n800_n130#
+ sky130_fd_pr__nfet_01v8_6BSMN9$7$2
.ends

.subckt sky130_fd_pr__nfet_01v8_6BSMN9$9 a_800_n42# a_n960_n216# a_n858_n42# a_n800_n130#
X0 a_800_n42# a_n800_n130# a_n858_n42# a_n960_n216# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt x024w8l_nmos$9 sky130_fd_pr__nfet_01v8_6BSMN9$9_0/a_800_n42# sky130_fd_pr__nfet_01v8_6BSMN9$9_0/a_n800_n130#
+ sky130_fd_pr__nfet_01v8_6BSMN9$9_0/a_n858_n42# VSUBS
Xsky130_fd_pr__nfet_01v8_6BSMN9$9_0 sky130_fd_pr__nfet_01v8_6BSMN9$9_0/a_800_n42#
+ VSUBS sky130_fd_pr__nfet_01v8_6BSMN9$9_0/a_n858_n42# sky130_fd_pr__nfet_01v8_6BSMN9$9_0/a_n800_n130#
+ sky130_fd_pr__nfet_01v8_6BSMN9$9
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_AWGYQ2$2 c1_n5265_n5346# m3_n5365_n5446# m3_230_n5446#
+ c1_330_n5346#
X0 c1_n5265_n5346# m3_n5365_n5446# sky130_fd_pr__cap_mim_m3_1 l=2.528e+07u w=2.528e+07u
X1 c1_330_n5346# m3_230_n5446# sky130_fd_pr__cap_mim_m3_1 l=2.528e+07u w=2.528e+07u
X2 c1_330_n5346# m3_230_n5446# sky130_fd_pr__cap_mim_m3_1 l=2.528e+07u w=2.528e+07u
X3 c1_n5265_n5346# m3_n5365_n5446# sky130_fd_pr__cap_mim_m3_1 l=2.528e+07u w=2.528e+07u
.ends

.subckt x5p_capacitor$2 sky130_fd_pr__cap_mim_m3_1_AWGYQ2$2_0/c1_330_n5346# sky130_fd_pr__cap_mim_m3_1_AWGYQ2$2_0/c1_n5265_n5346#
+ sky130_fd_pr__cap_mim_m3_1_AWGYQ2$2_0/m3_n5365_n5446# sky130_fd_pr__cap_mim_m3_1_AWGYQ2$2_0/m3_230_n5446#
Xsky130_fd_pr__cap_mim_m3_1_AWGYQ2$2_0 sky130_fd_pr__cap_mim_m3_1_AWGYQ2$2_0/c1_n5265_n5346#
+ sky130_fd_pr__cap_mim_m3_1_AWGYQ2$2_0/m3_n5365_n5446# sky130_fd_pr__cap_mim_m3_1_AWGYQ2$2_0/m3_230_n5446#
+ sky130_fd_pr__cap_mim_m3_1_AWGYQ2$2_0/c1_330_n5346# sky130_fd_pr__cap_mim_m3_1_AWGYQ2$2
.ends

.subckt sky130_fd_pr__pfet_01v8_589FFS$3 w_n996_n261# a_n800_n139# a_800_n42# a_n858_n42#
X0 a_800_n42# a_n800_n139# a_n858_n42# w_n996_n261# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt x042w8l_pmos$3 sky130_fd_pr__pfet_01v8_589FFS$3_0/a_800_n42# sky130_fd_pr__pfet_01v8_589FFS$3_0/a_n858_n42#
+ sky130_fd_pr__pfet_01v8_589FFS$3_0/w_n996_n261# sky130_fd_pr__pfet_01v8_589FFS$3_0/a_n800_n139#
Xsky130_fd_pr__pfet_01v8_589FFS$3_0 sky130_fd_pr__pfet_01v8_589FFS$3_0/w_n996_n261#
+ sky130_fd_pr__pfet_01v8_589FFS$3_0/a_n800_n139# sky130_fd_pr__pfet_01v8_589FFS$3_0/a_800_n42#
+ sky130_fd_pr__pfet_01v8_589FFS$3_0/a_n858_n42# sky130_fd_pr__pfet_01v8_589FFS$3
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_9B94PP$9 c1_n738_n688# m3_n838_n788#
X0 c1_n738_n688# m3_n838_n788# sky130_fd_pr__cap_mim_m3_1 l=6.88e+06u w=6.88e+06u
.ends

.subckt x100f_capacitor$9 sky130_fd_pr__cap_mim_m3_1_9B94PP$9_0/c1_n738_n688# sky130_fd_pr__cap_mim_m3_1_9B94PP$9_0/m3_n838_n788#
Xsky130_fd_pr__cap_mim_m3_1_9B94PP$9_0 sky130_fd_pr__cap_mim_m3_1_9B94PP$9_0/c1_n738_n688#
+ sky130_fd_pr__cap_mim_m3_1_9B94PP$9_0/m3_n838_n788# sky130_fd_pr__cap_mim_m3_1_9B94PP$9
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_8NU5HM$3 c1_n2155_n7555# m3_n7444_n7655# m3_n2255_n7655#
+ m3_n7444_n2565# c1_3034_n7555# m3_2934_n7655# c1_n7344_n7555#
X0 c1_n7344_n7555# m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X1 c1_n2155_n7555# m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X2 c1_n7344_n7555# m3_n7444_n2565# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X3 c1_n2155_n7555# m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X4 c1_3034_n7555# m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X5 c1_3034_n7555# m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X6 c1_n2155_n7555# m3_n2255_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X7 c1_3034_n7555# m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
X8 c1_n7344_n7555# m3_n7444_n2565# sky130_fd_pr__cap_mim_m3_1 l=2.325e+07u w=2.325e+07u
.ends

.subckt x10p_capacitor$3 sky130_fd_pr__cap_mim_m3_1_8NU5HM$3_0/c1_n7344_n7555# sky130_fd_pr__cap_mim_m3_1_8NU5HM$3_0/c1_3034_n7555#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$3_0/m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1_8NU5HM$3_0/c1_n2155_n7555#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$3_0/m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1_8NU5HM$3_0/m3_n2255_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$3_0/m3_n7444_n2565#
Xsky130_fd_pr__cap_mim_m3_1_8NU5HM$3_0 sky130_fd_pr__cap_mim_m3_1_8NU5HM$3_0/c1_n2155_n7555#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$3_0/m3_n7444_n7655# sky130_fd_pr__cap_mim_m3_1_8NU5HM$3_0/m3_n2255_n7655#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$3_0/m3_n7444_n2565# sky130_fd_pr__cap_mim_m3_1_8NU5HM$3_0/c1_3034_n7555#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$3_0/m3_2934_n7655# sky130_fd_pr__cap_mim_m3_1_8NU5HM$3_0/c1_n7344_n7555#
+ sky130_fd_pr__cap_mim_m3_1_8NU5HM$3
.ends

.subckt sky130_fd_pr__nfet_01v8_28DC9G$2 a_n150_n788# a_n310_n874# a_150_n700# a_n208_n700#
X0 a_150_n700# a_n150_n788# a_n208_n700# a_n310_n874# sky130_fd_pr__nfet_01v8 ad=2.03e+12p pd=1.458e+07u as=2.03e+12p ps=1.458e+07u w=7e+06u l=1.5e+06u
.ends

.subckt x7w1_5l_nmos$2 sky130_fd_pr__nfet_01v8_28DC9G$2_0/a_n150_n788# sky130_fd_pr__nfet_01v8_28DC9G$2_0/a_150_n700#
+ sky130_fd_pr__nfet_01v8_28DC9G$2_0/a_n208_n700# VSUBS
Xsky130_fd_pr__nfet_01v8_28DC9G$2_0 sky130_fd_pr__nfet_01v8_28DC9G$2_0/a_n150_n788#
+ VSUBS sky130_fd_pr__nfet_01v8_28DC9G$2_0/a_150_n700# sky130_fd_pr__nfet_01v8_28DC9G$2_0/a_n208_n700#
+ sky130_fd_pr__nfet_01v8_28DC9G$2
.ends

.subckt sky130_fd_pr__nfet_01v8_6BSMN9$6$2 a_800_n42# a_n960_n216# a_n858_n42# a_n800_n130#
X0 a_800_n42# a_n800_n130# a_n858_n42# a_n960_n216# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt x024w8l_nmos$6$2 sky130_fd_pr__nfet_01v8_6BSMN9$6$2_0/a_800_n42# sky130_fd_pr__nfet_01v8_6BSMN9$6$2_0/a_n800_n130#
+ sky130_fd_pr__nfet_01v8_6BSMN9$6$2_0/a_n858_n42# VSUBS
Xsky130_fd_pr__nfet_01v8_6BSMN9$6$2_0 sky130_fd_pr__nfet_01v8_6BSMN9$6$2_0/a_800_n42#
+ VSUBS sky130_fd_pr__nfet_01v8_6BSMN9$6$2_0/a_n858_n42# sky130_fd_pr__nfet_01v8_6BSMN9$6$2_0/a_n800_n130#
+ sky130_fd_pr__nfet_01v8_6BSMN9$6$2
.ends

.subckt sky130_fd_pr__nfet_01v8_ZEJXTR$2 a_42_n5000# a_n202_n5174# a_n42_n5088# a_n100_n5000#
X0 a_42_n5000# a_n42_n5088# a_n100_n5000# a_n202_n5174# sky130_fd_pr__nfet_01v8 ad=1.45e+13p pd=1.0058e+08u as=1.45e+13p ps=1.0058e+08u w=5e+07u l=420000u
.ends

.subckt x50w042l_nmos$2 sky130_fd_pr__nfet_01v8_ZEJXTR$2_0/a_42_n5000# sky130_fd_pr__nfet_01v8_ZEJXTR$2_0/a_n100_n5000#
+ sky130_fd_pr__nfet_01v8_ZEJXTR$2_0/a_n42_n5088# VSUBS
Xsky130_fd_pr__nfet_01v8_ZEJXTR$2_0 sky130_fd_pr__nfet_01v8_ZEJXTR$2_0/a_42_n5000#
+ VSUBS sky130_fd_pr__nfet_01v8_ZEJXTR$2_0/a_n42_n5088# sky130_fd_pr__nfet_01v8_ZEJXTR$2_0/a_n100_n5000#
+ sky130_fd_pr__nfet_01v8_ZEJXTR$2
.ends

.subckt sky130_fd_pr__pfet_01v8_589FFS$1$2 w_n996_n261# a_n800_n139# a_800_n42# a_n858_n42#
X0 a_800_n42# a_n800_n139# a_n858_n42# w_n996_n261# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt x042w8l_pmos$1$2 sky130_fd_pr__pfet_01v8_589FFS$1$2_0/w_n996_n261# sky130_fd_pr__pfet_01v8_589FFS$1$2_0/a_800_n42#
+ sky130_fd_pr__pfet_01v8_589FFS$1$2_0/a_n800_n139# sky130_fd_pr__pfet_01v8_589FFS$1$2_0/a_n858_n42#
Xsky130_fd_pr__pfet_01v8_589FFS$1$2_0 sky130_fd_pr__pfet_01v8_589FFS$1$2_0/w_n996_n261#
+ sky130_fd_pr__pfet_01v8_589FFS$1$2_0/a_n800_n139# sky130_fd_pr__pfet_01v8_589FFS$1$2_0/a_800_n42#
+ sky130_fd_pr__pfet_01v8_589FFS$1$2_0/a_n858_n42# sky130_fd_pr__pfet_01v8_589FFS$1$2
.ends

.subckt sky130_fd_pr__pfet_01v8_U2PZU3$1$2 w_n238_n261# a_n100_n42# a_n42_n139# a_42_n42#
X0 a_42_n42# a_n42_n139# a_n100_n42# w_n238_n261# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=420000u
.ends

.subckt x042w042l_pmos$1$2 sky130_fd_pr__pfet_01v8_U2PZU3$1$2_0/w_n238_n261# sky130_fd_pr__pfet_01v8_U2PZU3$1$2_0/a_n42_n139#
+ sky130_fd_pr__pfet_01v8_U2PZU3$1$2_0/a_n100_n42# sky130_fd_pr__pfet_01v8_U2PZU3$1$2_0/a_42_n42#
Xsky130_fd_pr__pfet_01v8_U2PZU3$1$2_0 sky130_fd_pr__pfet_01v8_U2PZU3$1$2_0/w_n238_n261#
+ sky130_fd_pr__pfet_01v8_U2PZU3$1$2_0/a_n100_n42# sky130_fd_pr__pfet_01v8_U2PZU3$1$2_0/a_n42_n139#
+ sky130_fd_pr__pfet_01v8_U2PZU3$1$2_0/a_42_n42# sky130_fd_pr__pfet_01v8_U2PZU3$1$2
.ends

.subckt sky130_fd_pr__pfet_01v8_GJQV38$2 w_n546_n919# a_n350_n797# a_350_n700# a_n408_n700#
X0 a_350_n700# a_n350_n797# a_n408_n700# w_n546_n919# sky130_fd_pr__pfet_01v8 ad=2.03e+12p pd=1.458e+07u as=2.03e+12p ps=1.458e+07u w=7e+06u l=3.5e+06u
.ends

.subckt x7w3_5l_pmos$2 sky130_fd_pr__pfet_01v8_GJQV38$2_0/w_n546_n919# sky130_fd_pr__pfet_01v8_GJQV38$2_0/a_n350_n797#
+ sky130_fd_pr__pfet_01v8_GJQV38$2_0/a_n408_n700# sky130_fd_pr__pfet_01v8_GJQV38$2_0/a_350_n700#
Xsky130_fd_pr__pfet_01v8_GJQV38$2_0 sky130_fd_pr__pfet_01v8_GJQV38$2_0/w_n546_n919#
+ sky130_fd_pr__pfet_01v8_GJQV38$2_0/a_n350_n797# sky130_fd_pr__pfet_01v8_GJQV38$2_0/a_350_n700#
+ sky130_fd_pr__pfet_01v8_GJQV38$2_0/a_n408_n700# sky130_fd_pr__pfet_01v8_GJQV38$2
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_9B94PP$1$2 c1_n738_n928# m3_n838_n1028#
X0 c1_n738_n928# m3_n838_n1028# sky130_fd_pr__cap_mim_m3_1 l=6.88e+06u w=6.88e+06u
.ends

.subckt x100f_capacitor$1$2 sky130_fd_pr__cap_mim_m3_1_9B94PP$1$2_0/m3_n838_n1028#
+ sky130_fd_pr__cap_mim_m3_1_9B94PP$1$2_0/c1_n738_n928#
Xsky130_fd_pr__cap_mim_m3_1_9B94PP$1$2_0 sky130_fd_pr__cap_mim_m3_1_9B94PP$1$2_0/c1_n738_n928#
+ sky130_fd_pr__cap_mim_m3_1_9B94PP$1$2_0/m3_n838_n1028# sky130_fd_pr__cap_mim_m3_1_9B94PP$1$2
.ends

.subckt sky130_fd_pr__nfet_01v8_6BSMN9$5$2 a_800_n42# a_n960_n216# a_n858_n42# a_n800_n130#
X0 a_800_n42# a_n800_n130# a_n858_n42# a_n960_n216# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt x024w8l_nmos$5$2 sky130_fd_pr__nfet_01v8_6BSMN9$5$2_0/a_n858_n42# sky130_fd_pr__nfet_01v8_6BSMN9$5$2_0/a_n800_n130#
+ sky130_fd_pr__nfet_01v8_6BSMN9$5$2_0/a_800_n42# VSUBS
Xsky130_fd_pr__nfet_01v8_6BSMN9$5$2_0 sky130_fd_pr__nfet_01v8_6BSMN9$5$2_0/a_800_n42#
+ VSUBS sky130_fd_pr__nfet_01v8_6BSMN9$5$2_0/a_n858_n42# sky130_fd_pr__nfet_01v8_6BSMN9$5$2_0/a_n800_n130#
+ sky130_fd_pr__nfet_01v8_6BSMN9$5$2
.ends

.subckt sky130_fd_pr__nfet_01v8_ZZXZ62 a_800_n73# a_n800_n99# a_n858_n73# a_n960_n185#
X0 a_800_n73# a_n800_n99# a_n858_n73# a_n960_n185# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt nmos_l8u$1 nmos/a_n858_n73# nmos/a_n800_n99# nmos/a_800_n73# VSUBS
Xnmos nmos/a_800_n73# nmos/a_n800_n99# nmos/a_n858_n73# VSUBS sky130_fd_pr__nfet_01v8_ZZXZ62
.ends

.subckt sky130_fd_pr__pfet_01v8 a_800_n78# a_n800_n104# a_n858_n78# w_n996_n226#
X0 a_800_n78# a_n800_n104# a_n858_n78# w_n996_n226# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt pmos_l8u$1 pmos/w_n996_n226# pmos/a_n800_n104# pmos/a_800_n78# pmos/a_n858_n78#
Xpmos pmos/a_800_n78# pmos/a_n800_n104# pmos/a_n858_n78# pmos/w_n996_n226# sky130_fd_pr__pfet_01v8
.ends

.subckt pseudo_resistor_d4 m1_3611_n510# m1_2677_208# m1_1704_n2614# m1_n107_140#
+ m1_n107_n1055# VSUBS
Xnmos_l8u$1_0 VSUBS m1_2677_208# m1_91_n1395# VSUBS nmos_l8u$1
Xnmos_l8u$1_1 VSUBS m1_2677_208# m1_91_n2147# VSUBS nmos_l8u$1
Xnmos_l8u$1_2 VSUBS m1_3611_n510# m1_91_n1395# VSUBS nmos_l8u$1
Xnmos_l8u$1_3 VSUBS m1_1704_n2614# m1_91_n2147# VSUBS nmos_l8u$1
Xnmos_l8u$1_4 VSUBS m1_3611_n510# m1_91_n2147# VSUBS nmos_l8u$1
Xnmos_l8u$1_5 VSUBS m1_1704_n2614# m1_91_n1395# VSUBS nmos_l8u$1
Xpmos_l8u$1_1 m1_n107_n1055# m1_91_n1395# m1_n107_n1055# m1_91_n1395# pmos_l8u$1
Xpmos_l8u$1_0 m1_n107_140# m1_91_n1395# m1_1753_n647# m1_n107_140# pmos_l8u$1
Xpmos_l8u$1_2 m1_n107_n1055# m1_91_n2147# m1_1753_n647# m1_n107_n1055# pmos_l8u$1
Xpmos_l8u$1_3 m1_n107_140# m1_91_n2147# m1_n107_140# m1_91_n2147# pmos_l8u$1
.ends

.subckt OTA_tb_ps4 Vin1 Vin2 Vcasn Vss Vout Vdd Vcontrol2 Vcasp Vbias Vcontrol3 Vcontrol1
+ VSUBS
X50w1l_pmos$3_0 m3_3024_n301# Vdd m1_3282_6654# m1_3479_7472# x50w1l_pmos$3
X10p_capacitor$1$2_0 m1_4464_n2543# m4_n17304_11241# m4_n17304_11241# m1_4464_n2543#
+ m1_4464_n2543# m4_n17304_11241# x10p_capacitor$1$2
X042w042l_pmos$3_0 Vdd Vdd m1_2970_7585# m1_2970_7585# x042w042l_pmos$3
Xpads$9_0 m4_n17304_11241# Vdd Vbias m1_1809_4176# Vcontrol1 m4_n17596_23877# m2_n17561_n35245#
+ VSUBS Vout m1_3338_2243# pseudo_resistor_d4_0/m1_3611_n510# pads$9
X50w1l_pmos$1$2_0 m1_3248_6136# m1_3479_7472# m1_4464_n2543# Vdd x50w1l_pmos$1$2
X024w8l_nmos$7$2_0 VSUBS m1_3184_1154# m1_3282_6654# VSUBS x024w8l_nmos$7$2
X024w8l_nmos$9_0 m1_3248_6136# m1_3248_6136# VSUBS VSUBS x024w8l_nmos$9
X5p_capacitor$2_0 VSUBS VSUBS Vout Vout x5p_capacitor$2
X042w8l_pmos$3_0 m1_1326_3060# Vdd Vdd m1_3184_1154# x042w8l_pmos$3
X100f_capacitor$9_0 Vout m3_3024_n301# x100f_capacitor$9
X10p_capacitor$3_0 m4_n17596_23877# m4_n17596_23877# m3_3024_n301# m4_n17596_23877#
+ m3_3024_n301# m3_3024_n301# m3_3024_n301# x10p_capacitor$3
X7w1_5l_nmos$2_0 m1_1809_4176# Vout m1_1629_4037# VSUBS x7w1_5l_nmos$2
X024w8l_nmos$6$2_0 m1_1629_4037# m1_3248_6136# VSUBS VSUBS x024w8l_nmos$6$2
X50w042l_nmos$2_0 m1_2970_7585# VSUBS Vbias VSUBS x50w042l_nmos$2
X042w8l_pmos$1$2_0 Vdd m1_3184_1154# m1_3184_1154# Vdd x042w8l_pmos$1$2
X042w042l_pmos$1$2_0 Vdd m1_2970_7585# Vdd m1_3479_7472# x042w042l_pmos$1$2
X7w3_5l_pmos$2_0 Vdd m1_3338_2243# m1_1326_3060# Vout x7w3_5l_pmos$2
X100f_capacitor$1$2_0 VSUBS m1_4464_n2543# x100f_capacitor$1$2
X024w8l_nmos$5$2_0 VSUBS m1_3282_6654# m1_3282_6654# VSUBS x024w8l_nmos$5$2
Xpseudo_resistor_d4_0 pseudo_resistor_d4_0/m1_3611_n510# m2_n17561_n35245# Vcontrol1
+ m3_3024_n301# Vout VSUBS pseudo_resistor_d4
.ends

.subckt sky130_fd_pr__nfet_01v8_lvt_D7LUG4 RST VDD Ib D1 D2 D3 D4 D5 D6 D7 D1-N D2-N
+ D3-N-a D3-P-b D3-N-b D4-N-a D4-P-b D4-N-b D5-N-a D5-N-b D5-P-b D5-P-c D5-N-c D6-N-a
+ D6-N-b GND D7-N-c D7-N-b D7-N-a a_12347_63503# w_12412_197573# w_12412_185573# w_12312_17573#
+ w_12304_209497# w_12398_101543# w_12304_233497# li_5732_3953# w_12304_221497# w_12204_53497#
+ w_12592_149753#
X0 VDD w_12092_n6647# D1 GND sky130_fd_pr__nfet_01v8_lvt ad=1.3398e+13p pd=1.0052e+08u as=1.914e+12p ps=1.436e+07u w=3.3e+06u l=300000u
X1 VDD dw_12172_65433# D7 GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=1.914e+12p ps=1.436e+07u w=3.3e+06u l=300000u
X2 D5 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=6.699e+12p ps=5.026e+07u w=3.3e+06u l=300000u
X3 D4 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=0p ps=0u w=3.3e+06u l=300000u
X4 D1 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X5 w_12092_n6647# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=1.46957e+14p pd=2.9918e+08u as=0p ps=0u w=3.3e+06u l=300000u
X6 D6 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=0p ps=0u w=3.3e+06u l=300000u
X7 D2 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=0p ps=0u w=3.3e+06u l=300000u
D0 GND dw_12092_17353# sky130_fd_pr__model__parasitic__diode_ps2dn area=1e+14p
X8 VDD dw_12012_41273# D5 GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X9 VDD dw_12046_29291# D4 GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
D1 GND D6-N-b sky130_fd_pr__model__parasitic__diode_ps2dn area=1e+14p
X10 D3 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=0p ps=0u w=3.3e+06u l=300000u
X11 VDD dw_11948_53241# D6 GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X12 VDD a_12092_5353# D2 GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
D2 GND D7-N-a sky130_fd_pr__model__parasitic__diode_ps2dn area=3.2768e+14p
X13 dw_12172_65433# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=9.5165e+13p pd=3.0158e+08u as=0p ps=0u w=3.3e+06u l=300000u
X14 VDD dw_12092_17353# D3 GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
D3 GND D7-N-b sky130_fd_pr__model__parasitic__diode_ps2dn area=3.2768e+14p
D4 GND dw_14032_235353# sky130_fd_pr__model__parasitic__diode_ps2dn area=3.2768e+14p
X15 dw_11948_53241# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=1.01821e+14p pd=3.2078e+08u as=0p ps=0u w=3.3e+06u l=300000u
D5 GND dw_11948_53241# sky130_fd_pr__model__parasitic__diode_ps2dn area=3.2768e+14p
X16 a_12092_5353# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=1.42696e+15p pd=1.6118e+08u as=0p ps=0u w=3.3e+06u l=300000u
D6 GND D6-N-a sky130_fd_pr__model__parasitic__diode_ps2dn area=1e+14p
X17 dw_12092_17353# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=7.7957e+13p pd=3.1518e+08u as=0p ps=0u w=3.3e+06u l=300000u
X18 D7 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X19 dw_12012_41273# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=1.0608e+15p pd=4.3118e+08u as=0p ps=0u w=3.3e+06u l=300000u
X20 dw_12046_29291# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=9.6213e+13p pd=3.0958e+08u as=0p ps=0u w=3.3e+06u l=300000u
.ends

.subckt sky130_fd_pr__nfet_01v8_PTDE5C a_499_1522# a_342_1436# a_444_1610#
X0 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=1.0527e+13p pd=7.898e+07u as=9.57e+12p ps=7.18e+07u w=3.3e+06u l=300000u
X1 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X2 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X3 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X4 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X5 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X6 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X7 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X8 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X9 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X10 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X11 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X12 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X13 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X14 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X15 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X16 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X17 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X18 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X19 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
.ends

.subckt sky130_fd_pr__diode_pd2nw_05v5_LKJFLE a_3491_n1909# w_3353_n2047#
D0 a_3491_n1909# w_3353_n2047# sky130_fd_pr__diode_pd2nw_05v5 pj=2e+07u area=2.5e+13p
.ends

.subckt sky130_fd_pr__diode_pw2nd_05v5_VLZ7RW a_n500_n500# a_n602_n602#
D0 a_n602_n602# a_n500_n500# sky130_fd_pr__diode_pw2nd_05v5 pj=2e+07u area=2.5e+13p
.ends

.subckt photo_V4 sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D3-P-b w_10320_189420# w_10320_201420#
+ w_10112_57344# w_10500_153600# w_10306_105390# w_10212_237344# sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D5-P-c
+ w_10212_225344# sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D5-P-b w_10212_213344# w_10220_21420#
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/GND
Xsky130_fd_pr__nfet_01v8_lvt_D7LUG4_0 sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/RST sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/VDD
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/Ib sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D1
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D2 sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D3
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D4 sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D5
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D6 sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D7
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D1-N sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D2-N
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D3-N-a sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D3-P-b
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D3-N-b sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D4-N-a
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D4-P-b sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D4-N-b
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D5-N-a sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D5-N-b
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D5-P-b sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D5-P-c
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D5-N-c sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D6-N-a
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D6-N-b sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/GND
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D7-N-c sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D7-N-b
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D7-N-a sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/Ib
+ w_10320_201420# w_10320_189420# w_10220_21420# w_10212_213344# w_10306_105390# w_10212_237344#
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/GND w_10212_225344# w_10112_57344# w_10500_153600#
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4
Xsky130_fd_pr__nfet_01v8_PTDE5C_0 sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/Ib sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/GND
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/GND sky130_fd_pr__nfet_01v8_PTDE5C
Xsky130_fd_pr__diode_pd2nw_05v5_LKJFLE_0 sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/RST
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/VDD sky130_fd_pr__diode_pd2nw_05v5_LKJFLE
Xsky130_fd_pr__diode_pw2nd_05v5_VLZ7RW_0 sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/RST
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/GND sky130_fd_pr__diode_pw2nd_05v5_VLZ7RW
.ends

.subckt sky130_fd_pr__res_generic_nd_6V6VKZ a_n2012_n1516# a_n1889_1342# a_n1889_n1394#
X0 a_n1889_n1394# a_n1889_1342# a_n2012_n1516# sky130_fd_pr__res_generic_nd w=420000u l=3.7216e+08u
.ends

.subckt x126K_resistor li_n362_3416# li_n362_680# VSUBS
Xsky130_fd_pr__res_generic_nd_6V6VKZ_0 VSUBS li_n362_3416# li_n362_680# sky130_fd_pr__res_generic_nd_6V6VKZ
.ends

.subckt sky130_fd_pr__pfet_01v8_9GKHW3$5 a_n2270_11865# a_n2012_11865# a_n2212_11768#
+ w_n2408_11646#
X0 a_n2012_11865# a_n2212_11768# a_n2270_11865# w_n2408_11646# sky130_fd_pr__pfet_01v8 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
.ends

.subckt x2w1l_pmos$5 sky130_fd_pr__pfet_01v8_9GKHW3$5_0/a_n2270_11865# sky130_fd_pr__pfet_01v8_9GKHW3$5_0/a_n2012_11865#
+ sky130_fd_pr__pfet_01v8_9GKHW3$5_0/w_n2408_11646# sky130_fd_pr__pfet_01v8_9GKHW3$5_0/a_n2212_11768#
Xsky130_fd_pr__pfet_01v8_9GKHW3$5_0 sky130_fd_pr__pfet_01v8_9GKHW3$5_0/a_n2270_11865#
+ sky130_fd_pr__pfet_01v8_9GKHW3$5_0/a_n2012_11865# sky130_fd_pr__pfet_01v8_9GKHW3$5_0/a_n2212_11768#
+ sky130_fd_pr__pfet_01v8_9GKHW3$5_0/w_n2408_11646# sky130_fd_pr__pfet_01v8_9GKHW3$5
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_9B94PP$5 c1_n738_n772# m3_n838_n872#
X0 c1_n738_n772# m3_n838_n872# sky130_fd_pr__cap_mim_m3_1 l=6.88e+06u w=6.88e+06u
.ends

.subckt x100f_capacitor$5 sky130_fd_pr__cap_mim_m3_1_9B94PP$5_0/c1_n738_n772# sky130_fd_pr__cap_mim_m3_1_9B94PP$5_0/m3_n838_n872#
Xsky130_fd_pr__cap_mim_m3_1_9B94PP$5_0 sky130_fd_pr__cap_mim_m3_1_9B94PP$5_0/c1_n738_n772#
+ sky130_fd_pr__cap_mim_m3_1_9B94PP$5_0/m3_n838_n872# sky130_fd_pr__cap_mim_m3_1_9B94PP$5
.ends

.subckt sky130_fd_pr__nfet_01v8_BP3WK9$5 a_2167_n5338# a_1967_n5426# a_1909_n5338#
+ a_1807_n5512#
X0 a_2167_n5338# a_1967_n5426# a_1909_n5338# a_1807_n5512# sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt x1w1l_nmos$5 sky130_fd_pr__nfet_01v8_BP3WK9$5_0/a_2167_n5338# sky130_fd_pr__nfet_01v8_BP3WK9$5_0/a_1967_n5426#
+ sky130_fd_pr__nfet_01v8_BP3WK9$5_0/a_1909_n5338# VSUBS
Xsky130_fd_pr__nfet_01v8_BP3WK9$5_0 sky130_fd_pr__nfet_01v8_BP3WK9$5_0/a_2167_n5338#
+ sky130_fd_pr__nfet_01v8_BP3WK9$5_0/a_1967_n5426# sky130_fd_pr__nfet_01v8_BP3WK9$5_0/a_1909_n5338#
+ VSUBS sky130_fd_pr__nfet_01v8_BP3WK9$5
.ends

.subckt TIA_126k Vdd Vout Iin gnd
X126K_resistor_0 Iin m1_n956_n2654# gnd x126K_resistor
X2w1l_pmos$5_0 Vdd m1_n956_n2654# Vdd Iin x2w1l_pmos$5
X100f_capacitor$5_0 Vout m1_n956_n2654# x100f_capacitor$5
X1w1l_nmos$5_0 m1_n956_n2654# Iin gnd gnd x1w1l_nmos$5
.ends

.subckt pmos_lvt_CDNS_6626613181011 d s g b
X0 d g s b sky130_fd_pr__pfet_01v8_lvt ad=1.855e+12p pd=1.453e+07u as=1.855e+12p ps=1.453e+07u w=7e+06u l=350000u
.ends

.subckt pmos_v5_CDNS_662661318109 d s g b
X0 d g s b sky130_fd_pr__pfet_g5v0d10v5 ad=1.855e+12p pd=1.453e+07u as=1.855e+12p ps=1.453e+07u w=7e+06u l=8e+06u
.ends

.subckt pmos_v5_CDNS_662661318107 d s g b
X0 d g s b sky130_fd_pr__pfet_g5v0d10v5 ad=1.855e+12p pd=1.453e+07u as=1.855e+12p ps=1.453e+07u w=7e+06u l=500000u
.ends

.subckt pmos_lvt_CDNS_6626613181012 d s g b
X0 d g s b sky130_fd_pr__pfet_01v8_lvt ad=1.855e+12p pd=1.453e+07u as=1.855e+12p ps=1.453e+07u w=7e+06u l=8e+06u
.ends

.subckt pmos_lvt_CDNS_6626613181010 d s g b
X0 d g s b sky130_fd_pr__pfet_01v8_lvt ad=1.855e+12p pd=1.453e+07u as=1.855e+12p ps=1.453e+07u w=7e+06u l=350000u
.ends

.subckt pmos_v5_CDNS_662661318108 d s g b
X0 d g s b sky130_fd_pr__pfet_g5v0d10v5 ad=1.855e+12p pd=1.453e+07u as=1.855e+12p ps=1.453e+07u w=7e+06u l=500000u
.ends

.subckt cascodetests_P pcas_outtap pcas_intap pcas_out pcas_in pcas_long vddd pcas_diode
+ pcas5V_outtap pcas5V_intap pcas5V_out pcas5V_in pcas5V_long pcas5V_diode VDDA
Xpmos_lvt_CDNS_6626613181011_0 pcas_outtap pmos_lvt_CDNS_6626613181011_0/s pcas_long
+ vddd pmos_lvt_CDNS_6626613181011
Xpmos_lvt_CDNS_6626613181011_1 pcas_intap pmos_lvt_CDNS_6626613181011_1/s pcas_long
+ vddd pmos_lvt_CDNS_6626613181011
Xpmos_v5_CDNS_662661318109_0 pmos_v5_CDNS_662661318109_0/d pcas5V_diode pcas5V_long
+ VDDA pmos_v5_CDNS_662661318109
Xpmos_v5_CDNS_662661318109_1 pcas5V_long pcas5V_diode pcas5V_long VDDA pmos_v5_CDNS_662661318109
Xpmos_v5_CDNS_662661318107_0 VDDA pmos_v5_CDNS_662661318109_0/d pcas5V_long VDDA pmos_v5_CDNS_662661318107
Xpmos_v5_CDNS_662661318107_1 VDDA pcas5V_outtap pcas5V_in VDDA pmos_v5_CDNS_662661318107
Xpmos_v5_CDNS_662661318107_2 VDDA pcas5V_intap pcas5V_in VDDA pmos_v5_CDNS_662661318107
Xpmos_lvt_CDNS_6626613181012_0 pmos_lvt_CDNS_6626613181012_0/d pcas_diode pcas_long
+ vddd pmos_lvt_CDNS_6626613181012
Xpmos_lvt_CDNS_6626613181012_1 pcas_long pcas_diode pcas_long vddd pmos_lvt_CDNS_6626613181012
Xpmos_lvt_CDNS_6626613181010_0 vddd pmos_lvt_CDNS_6626613181012_0/d pcas_long vddd
+ pmos_lvt_CDNS_6626613181010
Xpmos_lvt_CDNS_6626613181010_1 vddd pcas_intap pcas_in vddd pmos_lvt_CDNS_6626613181010
Xpmos_lvt_CDNS_6626613181010_2 vddd pcas_outtap pcas_in vddd pmos_lvt_CDNS_6626613181010
Xpmos_v5_CDNS_662661318108_0 pcas5V_outtap pcas5V_out pcas5V_long VDDA pmos_v5_CDNS_662661318108
Xpmos_v5_CDNS_662661318108_1 pcas5V_intap pcas5V_in pcas5V_long VDDA pmos_v5_CDNS_662661318108
.ends

.subckt nmos_lvt_CDNS_662661318100 d s g a_n53_0# a_30_0# b
X0 a_30_0# g a_n53_0# b sky130_fd_pr__nfet_01v8_lvt ad=1.325e+12p pd=1.053e+07u as=1.325e+12p ps=1.053e+07u w=5e+06u l=150000u
.ends

.subckt nmos_v5_CDNS_662661318103 d s g a_n53_0# b a_1600_0#
X0 a_1600_0# g a_n53_0# b sky130_fd_pr__nfet_g5v0d10v5 ad=1.325e+12p pd=1.053e+07u as=1.325e+12p ps=1.053e+07u w=5e+06u l=8e+06u
.ends

.subckt nmos_lvt_CDNS_662661318105 d s g a_n53_0# b a_1600_0#
X0 a_1600_0# g a_n53_0# b sky130_fd_pr__nfet_01v8_lvt ad=1.325e+12p pd=1.053e+07u as=1.325e+12p ps=1.053e+07u w=5e+06u l=8e+06u
.ends

.subckt nmos_v5_CDNS_662661318101 d s g a_n53_0# b a_100_0#
X0 a_100_0# g a_n53_0# b sky130_fd_pr__nfet_g5v0d10v5 ad=1.325e+12p pd=1.053e+07u as=1.325e+12p ps=1.053e+07u w=5e+06u l=500000u
.ends

.subckt nmos_v5_CDNS_662661318102 d s g a_n53_0# b a_100_0#
X0 a_100_0# g a_n53_0# b sky130_fd_pr__nfet_g5v0d10v5 ad=1.325e+12p pd=1.053e+07u as=1.325e+12p ps=1.053e+07u w=5e+06u l=500000u
.ends

.subckt nmos_lvt_CDNS_662661318104 d s g a_n53_0# a_30_0# b
X0 a_30_0# g a_n53_0# b sky130_fd_pr__nfet_01v8_lvt ad=1.325e+12p pd=1.053e+07u as=1.325e+12p ps=1.053e+07u w=5e+06u l=150000u
.ends

.subckt cascodetests_N_v2 ncas_outtap ncas_intap ncas_in ncas_out ncas_diode ncas_long
+ ncas5V_outtap ncas5V_intap ncas5V_in ncas5V_out ncas5V_diode ncas5V_long gnd
Xnmos_lvt_CDNS_662661318100_1 nmos_lvt_CDNS_662661318100_1/d nmos_lvt_CDNS_662661318100_1/s
+ ncas_in m1_7600_275# gnd gnd nmos_lvt_CDNS_662661318100
Xnmos_lvt_CDNS_662661318100_2 nmos_lvt_CDNS_662661318100_2/d nmos_lvt_CDNS_662661318100_2/s
+ ncas_long m1_5190_274# gnd gnd nmos_lvt_CDNS_662661318100
Xnmos_v5_CDNS_662661318103_0 nmos_v5_CDNS_662661318103_0/d nmos_v5_CDNS_662661318103_0/s
+ ncas5V_long ncas5V_diode gnd m1_152_392# nmos_v5_CDNS_662661318103
Xnmos_lvt_CDNS_662661318105_0 nmos_lvt_CDNS_662661318105_0/d nmos_lvt_CDNS_662661318105_0/s
+ ncas_long m1_4166_2056# gnd ncas_long nmos_lvt_CDNS_662661318105
Xnmos_v5_CDNS_662661318103_1 nmos_v5_CDNS_662661318103_1/d nmos_v5_CDNS_662661318103_1/s
+ ncas5V_long ncas5V_diode gnd ncas5V_long nmos_v5_CDNS_662661318103
Xnmos_lvt_CDNS_662661318105_1 nmos_lvt_CDNS_662661318105_1/d nmos_lvt_CDNS_662661318105_1/s
+ ncas_long ncas_diode gnd m1_5190_274# nmos_lvt_CDNS_662661318105
Xnmos_v5_CDNS_662661318101_0 nmos_v5_CDNS_662661318101_0/d nmos_v5_CDNS_662661318101_0/s
+ ncas5V_long m1_152_392# gnd gnd nmos_v5_CDNS_662661318101
Xnmos_v5_CDNS_662661318101_1 nmos_v5_CDNS_662661318101_1/d nmos_v5_CDNS_662661318101_1/s
+ nmos_v5_CDNS_662661318101_2/g m1_1543_373# gnd gnd nmos_v5_CDNS_662661318101
Xnmos_v5_CDNS_662661318101_2 nmos_v5_CDNS_662661318101_2/d nmos_v5_CDNS_662661318101_2/s
+ nmos_v5_CDNS_662661318101_2/g m1_2692_373# gnd gnd nmos_v5_CDNS_662661318101
Xnmos_v5_CDNS_662661318102_0 nmos_v5_CDNS_662661318102_0/d nmos_v5_CDNS_662661318102_0/s
+ ncas5V_long nmos_v5_CDNS_662661318102_0/a_n53_0# gnd m1_1543_373# nmos_v5_CDNS_662661318102
Xnmos_lvt_CDNS_662661318104_1 nmos_lvt_CDNS_662661318104_1/d nmos_lvt_CDNS_662661318104_1/s
+ ncas_long m1_7648_484# m1_7600_275# gnd nmos_lvt_CDNS_662661318104
Xnmos_lvt_CDNS_662661318104_0 nmos_lvt_CDNS_662661318104_0/d nmos_lvt_CDNS_662661318104_0/s
+ ncas_long ncas_out ncas_outtap gnd nmos_lvt_CDNS_662661318104
Xnmos_v5_CDNS_662661318102_1 nmos_v5_CDNS_662661318102_1/d nmos_v5_CDNS_662661318102_1/s
+ ncas5V_long nmos_v5_CDNS_662661318101_2/g gnd m1_2692_373# nmos_v5_CDNS_662661318102
Xnmos_lvt_CDNS_662661318100_0 nmos_lvt_CDNS_662661318100_0/d nmos_lvt_CDNS_662661318100_0/s
+ ncas_in m1_6522_273# gnd gnd nmos_lvt_CDNS_662661318100
.ends

.subckt cascodetestsWithPads cascodetests_N_v2_0/gnd
Xcascodetests_P_0 cascodetests_P_0/pcas_outtap cascodetests_P_0/pcas_intap cascodetests_P_0/pcas_out
+ cascodetests_P_0/pcas_in cascodetests_P_0/pcas_long cascodetests_P_0/vddd cascodetests_P_0/pcas_diode
+ cascodetests_P_0/pcas5V_outtap cascodetests_P_0/pcas5V_intap cascodetests_P_0/pcas5V_out
+ cascodetests_P_0/pcas5V_in cascodetests_P_0/pcas5V_long cascodetests_P_0/pcas5V_diode
+ cascodetests_P_0/VDDA cascodetests_P
Xcascodetests_N_v2_0 cascodetests_N_v2_0/ncas_outtap cascodetests_N_v2_0/ncas_intap
+ cascodetests_N_v2_0/ncas_in cascodetests_N_v2_0/ncas_out cascodetests_N_v2_0/ncas_diode
+ cascodetests_N_v2_0/ncas_long pad_bond_CDNS_662661318106_10/PAD cascodetests_N_v2_0/ncas5V_intap
+ cascodetests_N_v2_0/ncas5V_in cascodetests_N_v2_0/ncas5V_out pad_bond_CDNS_662661318106_9/PAD
+ cascodetests_N_v2_0/ncas5V_long cascodetests_N_v2_0/gnd cascodetests_N_v2
.ends

.subckt sky130_fd_pr__pfet_01v8_UCG7GH a_n81_n600# a_n269_n600# a_n225_631# a_207_n600#
+ a_15_n600# a_n177_n600# a_111_n600# w_n407_n819#
X0 a_207_n600# a_n225_631# a_111_n600# w_n407_n819# sky130_fd_pr__pfet_01v8 ad=1.86e+12p pd=1.262e+07u as=1.98e+12p ps=1.266e+07u w=6e+06u l=150000u
X1 a_n177_n600# a_n225_631# a_n269_n600# w_n407_n819# sky130_fd_pr__pfet_01v8 ad=1.98e+12p pd=1.266e+07u as=1.86e+12p ps=1.262e+07u w=6e+06u l=150000u
X2 a_111_n600# a_n225_631# a_15_n600# w_n407_n819# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=1.98e+12p ps=1.266e+07u w=6e+06u l=150000u
X3 a_n81_n600# a_n225_631# a_n177_n600# w_n407_n819# sky130_fd_pr__pfet_01v8 ad=1.98e+12p pd=1.266e+07u as=0p ps=0u w=6e+06u l=150000u
X4 a_15_n600# a_n225_631# a_n81_n600# w_n407_n819# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=6e+06u l=150000u
.ends

.subckt pmos20 G D S B
Xpmos20 D D G S S S D B sky130_fd_pr__pfet_01v8_UCG7GH
.ends

.subckt NOISE_INJECTION$2 D[3] D[0] D[1] D[2] bias_out Noise_in VSS
X0 VSS D[1] a_430_3669# VSS sky130_fd_pr__nfet_01v8 ad=2.6712e+12p pd=3.288e+07u as=3.528e+11p ps=4.2e+06u w=420000u l=150000u
X1 VSS D[1] a_430_3669# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 VSS D[1] a_430_3669# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 bias_out a_430_2231# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X4 a_430_677# D[3] VSS VSS sky130_fd_pr__nfet_01v8 ad=3.528e+11p pd=4.2e+06u as=0p ps=0u w=420000u l=150000u
X5 Noise_in a_430_2231# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X6 VSS D[3] a_430_677# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 bias_out a_430_5223# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X8 a_430_5223# D[0] VSS VSS sky130_fd_pr__nfet_01v8 ad=3.528e+11p pd=4.2e+06u as=0p ps=0u w=420000u l=150000u
X9 Noise_in a_430_5223# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X10 a_430_5223# D[0] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 a_430_5223# D[0] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X12 VSS D[0] a_430_5223# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X13 VSS D[0] a_430_5223# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X14 VSS D[0] a_430_5223# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X15 a_430_2231# D[2] VSS VSS sky130_fd_pr__nfet_01v8 ad=3.528e+11p pd=4.2e+06u as=0p ps=0u w=420000u l=150000u
X16 a_430_2231# D[2] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X17 a_430_2231# D[2] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X18 bias_out a_430_677# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X19 VSS D[2] a_430_2231# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X20 VSS D[2] a_430_2231# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X21 VSS D[2] a_430_2231# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X22 Noise_in a_430_677# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X23 a_430_677# D[3] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X24 VSS D[3] a_430_677# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X25 a_430_677# D[3] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X26 a_430_3669# D[1] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X27 VSS D[3] a_430_677# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X28 bias_out a_430_3669# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X29 a_430_3669# D[1] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X30 a_430_3669# D[1] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X31 Noise_in a_430_3669# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
.ends

.subckt noise_virtual noise_D[1] noise_D[2] noise_D[3] noise_D[0] VVDD VOUT Noise_in
+ VPWR VGND
Xpmos20_0 VGND VVDD VPWR VPWR pmos20
Xpmos20_1 VOUT VVDD VPWR VPWR pmos20
Xpmos20_2 VGND VVDD VPWR VPWR pmos20
Xpmos20_3 VOUT VVDD VPWR VPWR pmos20
Xpmos20_4 VGND VVDD VPWR VPWR pmos20
Xpmos20_5 VOUT VVDD VPWR VPWR pmos20
XNOISE_INJECTION$2_0 noise_D[3] noise_D[0] noise_D[1] noise_D[2] VOUT Noise_in VGND
+ NOISE_INJECTION$2
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_9B94PP$2 c1_n738_n688# m3_n838_n788#
X0 c1_n738_n688# m3_n838_n788# sky130_fd_pr__cap_mim_m3_1 l=6.88e+06u w=6.88e+06u
.ends

.subckt x100f_capacitor$2 sky130_fd_pr__cap_mim_m3_1_9B94PP$2_0/m3_n838_n788# sky130_fd_pr__cap_mim_m3_1_9B94PP$2_0/c1_n738_n688#
Xsky130_fd_pr__cap_mim_m3_1_9B94PP$2_0 sky130_fd_pr__cap_mim_m3_1_9B94PP$2_0/c1_n738_n688#
+ sky130_fd_pr__cap_mim_m3_1_9B94PP$2_0/m3_n838_n788# sky130_fd_pr__cap_mim_m3_1_9B94PP$2
.ends

.subckt sky130_fd_pr__nfet_01v8_BP3WK9$2 a_2167_n5338# a_1967_n5426# a_1909_n5338#
+ a_1807_n5512#
X0 a_2167_n5338# a_1967_n5426# a_1909_n5338# a_1807_n5512# sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt x1w1l_nmos$2 sky130_fd_pr__nfet_01v8_BP3WK9$2_0/a_2167_n5338# sky130_fd_pr__nfet_01v8_BP3WK9$2_0/a_1967_n5426#
+ sky130_fd_pr__nfet_01v8_BP3WK9$2_0/a_1909_n5338# VSUBS
Xsky130_fd_pr__nfet_01v8_BP3WK9$2_0 sky130_fd_pr__nfet_01v8_BP3WK9$2_0/a_2167_n5338#
+ sky130_fd_pr__nfet_01v8_BP3WK9$2_0/a_1967_n5426# sky130_fd_pr__nfet_01v8_BP3WK9$2_0/a_1909_n5338#
+ VSUBS sky130_fd_pr__nfet_01v8_BP3WK9$2
.ends

.subckt sky130_fd_pr__res_generic_nd_RFGC98 a_1326_n6693# a_n1532_n6816# a_n1410_n6693#
X0 a_n1410_n6693# a_1326_n6693# a_n1532_n6816# sky130_fd_pr__res_generic_nd w=420000u l=1.32216e+09u
.ends

.subckt x434k_ndiff_resistor sky130_fd_pr__res_generic_nd_RFGC98_0/a_1326_n6693# sky130_fd_pr__res_generic_nd_RFGC98_0/a_n1410_n6693#
+ VSUBS
Xsky130_fd_pr__res_generic_nd_RFGC98_0 sky130_fd_pr__res_generic_nd_RFGC98_0/a_1326_n6693#
+ VSUBS sky130_fd_pr__res_generic_nd_RFGC98_0/a_n1410_n6693# sky130_fd_pr__res_generic_nd_RFGC98
.ends

.subckt sky130_fd_pr__pfet_01v8_9GKHW3$2 a_n2270_11865# a_n2012_11865# a_n2212_11768#
+ w_n2408_11646#
X0 a_n2012_11865# a_n2212_11768# a_n2270_11865# w_n2408_11646# sky130_fd_pr__pfet_01v8 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
.ends

.subckt x2w1l_pmos$2 sky130_fd_pr__pfet_01v8_9GKHW3$2_0/a_n2270_11865# sky130_fd_pr__pfet_01v8_9GKHW3$2_0/w_n2408_11646#
+ sky130_fd_pr__pfet_01v8_9GKHW3$2_0/a_n2012_11865# sky130_fd_pr__pfet_01v8_9GKHW3$2_0/a_n2212_11768#
Xsky130_fd_pr__pfet_01v8_9GKHW3$2_0 sky130_fd_pr__pfet_01v8_9GKHW3$2_0/a_n2270_11865#
+ sky130_fd_pr__pfet_01v8_9GKHW3$2_0/a_n2012_11865# sky130_fd_pr__pfet_01v8_9GKHW3$2_0/a_n2212_11768#
+ sky130_fd_pr__pfet_01v8_9GKHW3$2_0/w_n2408_11646# sky130_fd_pr__pfet_01v8_9GKHW3$2
.ends

.subckt TIA_434k Vdd Vout Iin gnd
X100f_capacitor$2_0 li_n6415_n2631# Vout x100f_capacitor$2
X1w1l_nmos$2_0 li_n6415_n2631# li_n6415_105# gnd gnd x1w1l_nmos$2
X434k_ndiff_resistor_0 li_n6415_n2631# li_n6415_105# gnd x434k_ndiff_resistor
X2w1l_pmos$2_0 Vdd Vdd li_n6415_n2631# li_n6415_105# x2w1l_pmos$2
.ends

.subckt sky130_fd_pr__res_generic_nd_T736LA$1$2 a_n42_n413# a_n42_310# a_n164_n535#
X0 a_n42_n413# a_n42_310# a_n164_n535# sky130_fd_pr__res_generic_nd w=420000u l=3.1e+06u
.ends

.subckt x1k_resistor$1$2 sky130_fd_pr__res_generic_nd_T736LA$1$2_0/a_n42_n413# sky130_fd_pr__res_generic_nd_T736LA$1$2_0/a_n42_310#
+ VSUBS
Xsky130_fd_pr__res_generic_nd_T736LA$1$2_0 sky130_fd_pr__res_generic_nd_T736LA$1$2_0/a_n42_n413#
+ sky130_fd_pr__res_generic_nd_T736LA$1$2_0/a_n42_310# VSUBS sky130_fd_pr__res_generic_nd_T736LA$1$2
.ends

.subckt sky130_fd_pr__res_generic_nd_46MAPF$1$2 a_318_n394# a_n402_n394# a_n524_n517#
X0 a_n402_n394# a_318_n394# a_n524_n517# sky130_fd_pr__res_generic_nd w=420000u l=1.91e+07u
.ends

.subckt x7_5k_resistor$1$2 sky130_fd_pr__res_generic_nd_46MAPF$1$2_0/a_318_n394# sky130_fd_pr__res_generic_nd_46MAPF$1$2_0/a_n402_n394#
+ VSUBS
Xsky130_fd_pr__res_generic_nd_46MAPF$1$2_0 sky130_fd_pr__res_generic_nd_46MAPF$1$2_0/a_318_n394#
+ sky130_fd_pr__res_generic_nd_46MAPF$1$2_0/a_n402_n394# VSUBS sky130_fd_pr__res_generic_nd_46MAPF$1$2
.ends

.subckt sky130_fd_pr__diode_pd2nw_05v5_XVBDD8$1$3 a_n112_n300# w_n250_n438#
D0 a_n112_n300# w_n250_n438# sky130_fd_pr__diode_pd2nw_05v5 pj=1.2e+07u area=9e+12p
.ends

.subckt p_diode$1$3 VSUBS sky130_fd_pr__diode_pd2nw_05v5_XVBDD8$1$3_0/w_n250_n438#
+ sky130_fd_pr__diode_pd2nw_05v5_XVBDD8$1$3_0/a_n112_n300#
Xsky130_fd_pr__diode_pd2nw_05v5_XVBDD8$1$3_0 sky130_fd_pr__diode_pd2nw_05v5_XVBDD8$1$3_0/a_n112_n300#
+ sky130_fd_pr__diode_pd2nw_05v5_XVBDD8$1$3_0/w_n250_n438# sky130_fd_pr__diode_pd2nw_05v5_XVBDD8$1$3
.ends

.subckt sky130_fd_pr__diode_pd2nw_05v5_XVBDD8$2$2 a_n300_n300# w_n438_n438#
D0 a_n300_n300# w_n438_n438# sky130_fd_pr__diode_pd2nw_05v5 pj=1.2e+07u area=9e+12p
.ends

.subckt p_diode$2$2 VSUBS sky130_fd_pr__diode_pd2nw_05v5_XVBDD8$2$2_0/w_n438_n438#
+ sky130_fd_pr__diode_pd2nw_05v5_XVBDD8$2$2_0/a_n300_n300#
Xsky130_fd_pr__diode_pd2nw_05v5_XVBDD8$2$2_0 sky130_fd_pr__diode_pd2nw_05v5_XVBDD8$2$2_0/a_n300_n300#
+ sky130_fd_pr__diode_pd2nw_05v5_XVBDD8$2$2_0/w_n438_n438# sky130_fd_pr__diode_pd2nw_05v5_XVBDD8$2$2
.ends

.subckt sky130_fd_pr__res_generic_nd_QDQXE7$2 a_n1100_n1446# a_n978_n1323# a_894_n1323#
X0 a_n978_n1323# a_894_n1323# a_n1100_n1446# sky130_fd_pr__res_generic_nd w=420000u l=1.7388e+08u
.ends

.subckt x60k_resistor$2 sky130_fd_pr__res_generic_nd_QDQXE7$2_0/a_894_n1323# sky130_fd_pr__res_generic_nd_QDQXE7$2_0/a_n978_n1323#
+ VSUBS
Xsky130_fd_pr__res_generic_nd_QDQXE7$2_0 VSUBS sky130_fd_pr__res_generic_nd_QDQXE7$2_0/a_n978_n1323#
+ sky130_fd_pr__res_generic_nd_QDQXE7$2_0/a_894_n1323# sky130_fd_pr__res_generic_nd_QDQXE7$2
.ends

.subckt sky130_fd_pr__diode_pd2nw_05v5_XVBDD8$4 a_n112_n300# w_n250_n438#
D0 a_n112_n300# w_n250_n438# sky130_fd_pr__diode_pd2nw_05v5 pj=1.2e+07u area=9e+12p
.ends

.subckt p_diode$4 sky130_fd_pr__diode_pd2nw_05v5_XVBDD8$4_0/a_n112_n300# sky130_fd_pr__diode_pd2nw_05v5_XVBDD8$4_0/w_n250_n438#
+ VSUBS
Xsky130_fd_pr__diode_pd2nw_05v5_XVBDD8$4_0 sky130_fd_pr__diode_pd2nw_05v5_XVBDD8$4_0/a_n112_n300#
+ sky130_fd_pr__diode_pd2nw_05v5_XVBDD8$4_0/w_n250_n438# sky130_fd_pr__diode_pd2nw_05v5_XVBDD8$4
.ends

.subckt sky130_fd_pr__res_generic_nd_HFGMAN$1 a_1182_n683# a_n1266_n683# a_n1388_n806#
X0 a_n1266_n683# a_1182_n683# a_n1388_n806# sky130_fd_pr__res_generic_nd w=420000u l=1.082e+08u
.ends

.subckt x40k_resistor$1 sky130_fd_pr__res_generic_nd_HFGMAN$1_0/a_1182_n683# sky130_fd_pr__res_generic_nd_HFGMAN$1_0/a_n1266_n683#
+ VSUBS
Xsky130_fd_pr__res_generic_nd_HFGMAN$1_0 sky130_fd_pr__res_generic_nd_HFGMAN$1_0/a_1182_n683#
+ sky130_fd_pr__res_generic_nd_HFGMAN$1_0/a_n1266_n683# VSUBS sky130_fd_pr__res_generic_nd_HFGMAN$1
.ends

.subckt sky130_fd_pr__res_generic_nd_GPGWDF$2 a_n1122_n386# a_n1244_n509# a_1038_n386#
X0 a_n1122_n386# a_1038_n386# a_n1244_n509# sky130_fd_pr__res_generic_nd w=420000u l=4.872e+07u
.ends

.subckt x20k_resistor$2 sky130_fd_pr__res_generic_nd_GPGWDF$2_0/a_n1122_n386# sky130_fd_pr__res_generic_nd_GPGWDF$2_0/a_1038_n386#
+ VSUBS
Xsky130_fd_pr__res_generic_nd_GPGWDF$2_0 sky130_fd_pr__res_generic_nd_GPGWDF$2_0/a_n1122_n386#
+ VSUBS sky130_fd_pr__res_generic_nd_GPGWDF$2_0/a_1038_n386# sky130_fd_pr__res_generic_nd_GPGWDF$2
.ends

.subckt sky130_fd_pr__res_generic_nd_T736LA$3$2 a_n42_n413# a_n42_310# a_n164_n535#
X0 a_n42_n413# a_n42_310# a_n164_n535# sky130_fd_pr__res_generic_nd w=420000u l=3.1e+06u
.ends

.subckt x1k_resistor$3$2 sky130_fd_pr__res_generic_nd_T736LA$3$2_0/a_n42_n413# sky130_fd_pr__res_generic_nd_T736LA$3$2_0/a_n42_310#
+ VSUBS
Xsky130_fd_pr__res_generic_nd_T736LA$3$2_0 sky130_fd_pr__res_generic_nd_T736LA$3$2_0/a_n42_n413#
+ sky130_fd_pr__res_generic_nd_T736LA$3$2_0/a_n42_310# VSUBS sky130_fd_pr__res_generic_nd_T736LA$3$2
.ends

.subckt sky130_fd_pr__res_generic_nd_46MAPF$3 a_318_n394# a_n402_n394# a_n524_n517#
X0 a_n402_n394# a_318_n394# a_n524_n517# sky130_fd_pr__res_generic_nd w=420000u l=1.91e+07u
.ends

.subckt x7_5k_resistor$3 sky130_fd_pr__res_generic_nd_46MAPF$3_0/a_n402_n394# sky130_fd_pr__res_generic_nd_46MAPF$3_0/a_318_n394#
+ VSUBS
Xsky130_fd_pr__res_generic_nd_46MAPF$3_0 sky130_fd_pr__res_generic_nd_46MAPF$3_0/a_318_n394#
+ sky130_fd_pr__res_generic_nd_46MAPF$3_0/a_n402_n394# VSUBS sky130_fd_pr__res_generic_nd_46MAPF$3
.ends

.subckt sky130_fd_pr__res_generic_nd_T736LA$5 a_n42_n413# a_n42_310# a_n164_n535#
X0 a_n42_n413# a_n42_310# a_n164_n535# sky130_fd_pr__res_generic_nd w=420000u l=3.1e+06u
.ends

.subckt x1k_resistor$5 sky130_fd_pr__res_generic_nd_T736LA$5_0/a_n42_n413# VSUBS sky130_fd_pr__res_generic_nd_T736LA$5_0/a_n42_310#
Xsky130_fd_pr__res_generic_nd_T736LA$5_0 sky130_fd_pr__res_generic_nd_T736LA$5_0/a_n42_n413#
+ sky130_fd_pr__res_generic_nd_T736LA$5_0/a_n42_310# VSUBS sky130_fd_pr__res_generic_nd_T736LA$5
.ends

.subckt sky130_fd_pr__res_generic_nd_T736LA$2$2 a_n42_n413# a_n42_310# a_n164_n535#
X0 a_n42_n413# a_n42_310# a_n164_n535# sky130_fd_pr__res_generic_nd w=420000u l=3.1e+06u
.ends

.subckt x1k_resistor$2$2 sky130_fd_pr__res_generic_nd_T736LA$2$2_0/a_n42_310# sky130_fd_pr__res_generic_nd_T736LA$2$2_0/a_n42_n413#
+ VSUBS
Xsky130_fd_pr__res_generic_nd_T736LA$2$2_0 sky130_fd_pr__res_generic_nd_T736LA$2$2_0/a_n42_n413#
+ sky130_fd_pr__res_generic_nd_T736LA$2$2_0/a_n42_310# VSUBS sky130_fd_pr__res_generic_nd_T736LA$2$2
.ends

.subckt sky130_fd_pr__res_generic_nd_HFGMAN a_1182_n683# a_n1266_n683# a_n1388_n806#
X0 a_n1266_n683# a_1182_n683# a_n1388_n806# sky130_fd_pr__res_generic_nd w=420000u l=1.082e+08u
.ends

.subckt x40k_resistor sky130_fd_pr__res_generic_nd_HFGMAN_0/a_n1266_n683# sky130_fd_pr__res_generic_nd_HFGMAN_0/a_1182_n683#
+ VSUBS
Xsky130_fd_pr__res_generic_nd_HFGMAN_0 sky130_fd_pr__res_generic_nd_HFGMAN_0/a_1182_n683#
+ sky130_fd_pr__res_generic_nd_HFGMAN_0/a_n1266_n683# VSUBS sky130_fd_pr__res_generic_nd_HFGMAN
.ends

.subckt MEMID Vread Vwriteplus Vwriteminus Vraw Vamp Voffset Vout Vdd Vi1 Vi2 Vss
+ T
X1k_resistor$1$2_0 a_43889_11140# Voffset T x1k_resistor$1$2
X7_5k_resistor$1$2_0 li_35355_10350# T T x7_5k_resistor$1$2
Xp_diode$1$3_0 T m1_24555_11287# m1_24568_11557# p_diode$1$3
Xp_diode$2$2_0 T Vwriteminus li_35355_10350# p_diode$2$2
X60k_resistor$2_0 a_43889_11140# li_25695_10406# T x60k_resistor$2
Xp_diode$4_0 li_28083_10366# m1_24816_12527# T p_diode$4
X40k_resistor$1_0 Vout li_25695_10406# T x40k_resistor$1
X20k_resistor$2_0 li_28083_10366# T T x20k_resistor$2
X1k_resistor$3$2_0 a_38738_11139# T T x1k_resistor$3$2
X7_5k_resistor$3_0 T m1_24568_11557# T x7_5k_resistor$3
X1k_resistor$5_0 T T T x1k_resistor$5
X1k_resistor$2$2_0 T T T x1k_resistor$2$2
X40k_resistor_0 a_38738_11139# a_39656_10269# T x40k_resistor
X0 a_38311_12241# a_38311_12241# w_38115_12119# w_38115_12119# sky130_fd_pr__pfet_01v8 ad=1.45e+12p pd=1.058e+07u as=4.35002e+12p ps=3.1745e+07u w=5e+06u l=1e+06u
X1 w_43711_11018# a_43462_12242# w_38115_12119# w_38115_12119# sky130_fd_pr__pfet_01v8 ad=2.03e+12p pd=1.574e+07u as=0p ps=0u w=5e+06u l=1e+06u
X2 a_43462_12242# a_43462_12242# w_38115_12119# w_38115_12119# sky130_fd_pr__pfet_01v8 ad=1.45e+12p pd=1.058e+07u as=0p ps=0u w=5e+06u l=1e+06u
X3 w_38560_11017# a_38311_12241# w_38115_12119# w_38115_12119# sky130_fd_pr__pfet_01v8 ad=2.03e+12p pd=1.574e+07u as=0p ps=0u w=5e+06u l=1e+06u
X4 Vout a_43627_10270# T T sky130_fd_pr__nfet_01v8 ad=2.16325e+11p pd=1.875e+06u as=2.89042e+12p ps=2.4705e+07u w=2e+06u l=1e+06u
X5 Vout a_43462_12242# w_38115_12119# w_38115_12119# sky130_fd_pr__pfet_01v8 ad=2.5e+07p pd=5000u as=0p ps=0u w=5e+06u l=1e+06u
X6 a_43427_10182# a_43889_11140# w_43711_11018# w_43711_11018# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=150000u
X7 a_38494_10269# a_38294_10181# T T sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=1e+06u
X8 a_38494_10269# T w_38560_11017# w_38560_11017# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=150000u
X9 a_39656_10269# a_38494_10269# T T sky130_fd_pr__nfet_01v8 ad=7.963e+11p pd=6.45e+06u as=0p ps=0u w=2e+06u l=1e+06u
X10 a_43427_10182# a_43427_10182# T T sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=1e+06u
X11 a_38294_10181# a_38294_10181# T T sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=1e+06u
X12 a_38494_10269# a_39656_10269# sky130_fd_pr__cap_mim_m3_1 l=9.19e+06u w=9.19e+06u
X13 a_43627_10270# Vout sky130_fd_pr__cap_mim_m3_1 l=9.19e+06u w=9.19e+06u
X14 a_43627_10270# a_39656_10269# w_43711_11018# w_43711_11018# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=150000u
X15 a_39656_10269# a_38311_12241# w_38115_12119# w_38115_12119# sky130_fd_pr__pfet_01v8 ad=2.5e+07p pd=5000u as=0p ps=0u w=5e+06u l=1e+06u
X16 a_43627_10270# a_43427_10182# T T sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=1e+06u
X17 a_38294_10181# a_38738_11139# w_38560_11017# w_38560_11017# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3 RST VDD Ib D1 D2 D3 D4 D5 D6 D7 D1-N
+ D2-N D3-N-a D3-P-b D3-N-b D4-N-a D4-P-b D4-N-b D5-N-a D5-N-b D5-P-b D5-P-c D5-N-c
+ D6-N-a D6-N-b GND D7-N-c D7-N-b D7-N-a a_12347_63503# w_12412_197573# w_12412_185573#
+ w_12312_17573# w_12304_209497# w_12398_101543# w_12304_233497# li_5732_3953# w_12304_221497#
+ w_12204_53497# w_12592_149753#
X0 VDD w_12092_n6647# D1 GND sky130_fd_pr__nfet_01v8_lvt ad=1.3398e+13p pd=1.0052e+08u as=1.914e+12p ps=1.436e+07u w=3.3e+06u l=300000u
X1 VDD dw_12172_65433# D7 GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=1.914e+12p ps=1.436e+07u w=3.3e+06u l=300000u
X2 D5 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=6.699e+12p ps=5.026e+07u w=3.3e+06u l=300000u
X3 D4 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=0p ps=0u w=3.3e+06u l=300000u
X4 D1 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X5 w_12092_n6647# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=1.46957e+14p pd=2.9918e+08u as=0p ps=0u w=3.3e+06u l=300000u
X6 D6 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=0p ps=0u w=3.3e+06u l=300000u
X7 D2 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=0p ps=0u w=3.3e+06u l=300000u
D0 GND dw_12092_17353# sky130_fd_pr__model__parasitic__diode_ps2dn area=1e+14p
X8 VDD dw_12012_41273# D5 GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X9 VDD dw_12046_29291# D4 GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
D1 GND D6-N-b sky130_fd_pr__model__parasitic__diode_ps2dn area=1e+14p
X10 D3 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=1.914e+12p pd=1.436e+07u as=0p ps=0u w=3.3e+06u l=300000u
X11 VDD dw_11948_53241# D6 GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X12 VDD a_12092_5353# D2 GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
D2 GND D7-N-a sky130_fd_pr__model__parasitic__diode_ps2dn area=3.2768e+14p
X13 dw_12172_65433# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=9.5165e+13p pd=3.0158e+08u as=0p ps=0u w=3.3e+06u l=300000u
X14 VDD dw_12092_17353# D3 GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
D3 GND D7-N-b sky130_fd_pr__model__parasitic__diode_ps2dn area=3.2768e+14p
D4 GND dw_14032_235353# sky130_fd_pr__model__parasitic__diode_ps2dn area=3.2768e+14p
X15 dw_11948_53241# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=1.01821e+14p pd=3.2078e+08u as=0p ps=0u w=3.3e+06u l=300000u
D5 GND dw_11948_53241# sky130_fd_pr__model__parasitic__diode_ps2dn area=3.2768e+14p
X16 a_12092_5353# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=1.42696e+15p pd=1.6118e+08u as=0p ps=0u w=3.3e+06u l=300000u
D6 GND D6-N-a sky130_fd_pr__model__parasitic__diode_ps2dn area=1e+14p
X17 dw_12092_17353# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=7.7957e+13p pd=3.1518e+08u as=0p ps=0u w=3.3e+06u l=300000u
X18 D7 a_12347_63503# GND GND sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X19 dw_12012_41273# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=1.0608e+15p pd=4.3118e+08u as=0p ps=0u w=3.3e+06u l=300000u
X20 dw_12046_29291# RST VDD GND sky130_fd_pr__nfet_01v8_lvt ad=9.6213e+13p pd=3.0958e+08u as=0p ps=0u w=3.3e+06u l=300000u
.ends

.subckt sky130_fd_pr__nfet_01v8_PTDE5C$3 a_499_1522# a_342_1436# a_444_1610#
X0 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=1.0527e+13p pd=7.898e+07u as=9.57e+12p ps=7.18e+07u w=3.3e+06u l=300000u
X1 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X2 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X3 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X4 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X5 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X6 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X7 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X8 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X9 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X10 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X11 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X12 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X13 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X14 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X15 a_499_1522# a_499_1522# a_444_1610# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X16 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X17 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X18 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
X19 a_444_1610# a_499_1522# a_499_1522# a_342_1436# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.3e+06u l=300000u
.ends

.subckt photo_V2 w_10320_189420# w_10320_201420# w_10112_57344# sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-P-c
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-P-b w_10500_153600# w_10306_105390# w_10212_237344#
+ w_10212_225344# w_10212_213344# sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D3-P-b w_10220_21420#
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/GND
Xsky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0 sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/RST
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/VDD sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/Ib
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D1 sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D2
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D3 sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D4
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5 sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D6
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D7 sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D1-N
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D2-N sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D3-N-a
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D3-P-b sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D3-N-b
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D4-N-a sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D4-P-b
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D4-N-b sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-N-a
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-N-b sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-P-b
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-P-c sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-N-c
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D6-N-a sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D6-N-b
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/GND sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D7-N-c
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D7-N-b sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D7-N-a
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/Ib w_10320_201420# w_10320_189420# w_10220_21420#
+ w_10212_213344# w_10306_105390# w_10212_237344# sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/GND
+ w_10212_225344# w_10112_57344# w_10500_153600# sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3
Xsky130_fd_pr__nfet_01v8_PTDE5C$3_0 sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/Ib sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/GND
+ sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/GND sky130_fd_pr__nfet_01v8_PTDE5C$3
.ends

.subckt sky130_fd_pr__nfet_01v8_BP3WK9 a_2167_n5338# a_1967_n5426# a_1909_n5338# a_1807_n5512#
X0 a_2167_n5338# a_1967_n5426# a_1909_n5338# a_1807_n5512# sky130_fd_pr__nfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt x1w1l_nmos sky130_fd_pr__nfet_01v8_BP3WK9_0/a_2167_n5338# sky130_fd_pr__nfet_01v8_BP3WK9_0/a_1967_n5426#
+ sky130_fd_pr__nfet_01v8_BP3WK9_0/a_1909_n5338# VSUBS
Xsky130_fd_pr__nfet_01v8_BP3WK9_0 sky130_fd_pr__nfet_01v8_BP3WK9_0/a_2167_n5338# sky130_fd_pr__nfet_01v8_BP3WK9_0/a_1967_n5426#
+ sky130_fd_pr__nfet_01v8_BP3WK9_0/a_1909_n5338# VSUBS sky130_fd_pr__nfet_01v8_BP3WK9
.ends

.subckt sky130_fd_pr__pfet_01v8_9GKHW3 a_n2270_11865# a_n2012_11865# a_n2212_11768#
+ w_n2408_11646#
X0 a_n2012_11865# a_n2212_11768# a_n2270_11865# w_n2408_11646# sky130_fd_pr__pfet_01v8 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
.ends

.subckt x2w1l_pmos sky130_fd_pr__pfet_01v8_9GKHW3_0/a_n2012_11865# sky130_fd_pr__pfet_01v8_9GKHW3_0/w_n2408_11646#
+ sky130_fd_pr__pfet_01v8_9GKHW3_0/a_n2212_11768# sky130_fd_pr__pfet_01v8_9GKHW3_0/a_n2270_11865#
Xsky130_fd_pr__pfet_01v8_9GKHW3_0 sky130_fd_pr__pfet_01v8_9GKHW3_0/a_n2270_11865#
+ sky130_fd_pr__pfet_01v8_9GKHW3_0/a_n2012_11865# sky130_fd_pr__pfet_01v8_9GKHW3_0/a_n2212_11768#
+ sky130_fd_pr__pfet_01v8_9GKHW3_0/w_n2408_11646# sky130_fd_pr__pfet_01v8_9GKHW3
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_9B94PP m3_n838_n845# c1_n738_n745#
X0 c1_n738_n745# m3_n838_n845# sky130_fd_pr__cap_mim_m3_1 l=6.88e+06u w=6.88e+06u
.ends

.subckt x100f_capacitor sky130_fd_pr__cap_mim_m3_1_9B94PP_0/m3_n838_n845# sky130_fd_pr__cap_mim_m3_1_9B94PP_0/c1_n738_n745#
Xsky130_fd_pr__cap_mim_m3_1_9B94PP_0 sky130_fd_pr__cap_mim_m3_1_9B94PP_0/m3_n838_n845#
+ sky130_fd_pr__cap_mim_m3_1_9B94PP_0/c1_n738_n745# sky130_fd_pr__cap_mim_m3_1_9B94PP
.ends

.subckt sky130_fd_pr__res_generic_nd_6U6PWG a_n1532_n10056# a_n1410_n9933# a_1326_n9933#
X0 a_n1410_n9933# a_1326_n9933# a_n1532_n10056# sky130_fd_pr__res_generic_nd w=420000u l=1.97016e+09u
.ends

.subckt x644k_ndiff_resistor sky130_fd_pr__res_generic_nd_6U6PWG_0/a_n1410_n9933#
+ sky130_fd_pr__res_generic_nd_6U6PWG_0/a_1326_n9933# VSUBS
Xsky130_fd_pr__res_generic_nd_6U6PWG_0 VSUBS sky130_fd_pr__res_generic_nd_6U6PWG_0/a_n1410_n9933#
+ sky130_fd_pr__res_generic_nd_6U6PWG_0/a_1326_n9933# sky130_fd_pr__res_generic_nd_6U6PWG
.ends

.subckt TIA_644k Vdd Vout Iin gnd
X1w1l_nmos_0 li_n8813_n2634# li_n8813_102# gnd gnd x1w1l_nmos
X2w1l_pmos_0 li_n8813_n2634# Vdd li_n8813_102# Vdd x2w1l_pmos
X100f_capacitor_0 li_n8813_n2634# Vout x100f_capacitor
X644k_ndiff_resistor_0 li_n8813_102# li_n8813_n2634# gnd x644k_ndiff_resistor
.ends

.subckt surfaceTestElement m3_n1000_n4401# m4_n4402_n1200# m3_n2000_n4401# m3_0_n4401#
+ m4_n4402_n600# m3_n3000_n4401# m3_1000_n4401# m3_n4000_n4401# m4_n4402_800# m4_n4402_200#
.ends

.subckt surfaceTestArray
XsurfaceTestElement_40 surfaceTestElement_7/m3_n1000_n4401# surfaceTestElement_49/m4_n4402_n1200#
+ surfaceTestElement_7/m3_n2000_n4401# surfaceTestElement_7/m3_0_n4401# surfaceTestElement_49/m4_n4402_n600#
+ surfaceTestElement_7/m3_n3000_n4401# surfaceTestElement_7/m3_1000_n4401# surfaceTestElement_7/m3_n4000_n4401#
+ surfaceTestElement_49/m4_n4402_800# surfaceTestElement_49/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_41 surfaceTestElement_7/m3_n1000_n4401# surfaceTestElement_48/m4_n4402_n1200#
+ surfaceTestElement_7/m3_n2000_n4401# surfaceTestElement_7/m3_0_n4401# surfaceTestElement_48/m4_n4402_n600#
+ surfaceTestElement_7/m3_n3000_n4401# surfaceTestElement_7/m3_1000_n4401# surfaceTestElement_7/m3_n4000_n4401#
+ surfaceTestElement_48/m4_n4402_800# surfaceTestElement_48/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_30 surfaceTestElement_0/m3_n1000_n4401# surfaceTestElement_49/m4_n4402_n1200#
+ surfaceTestElement_0/m3_n2000_n4401# surfaceTestElement_0/m3_0_n4401# surfaceTestElement_49/m4_n4402_n600#
+ surfaceTestElement_0/m3_n3000_n4401# surfaceTestElement_0/m3_1000_n4401# surfaceTestElement_0/m3_n4000_n4401#
+ surfaceTestElement_49/m4_n4402_800# surfaceTestElement_49/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_20 surfaceTestElement_1/m3_n1000_n4401# surfaceTestElement_24/m4_n4402_n1200#
+ surfaceTestElement_1/m3_n2000_n4401# surfaceTestElement_1/m3_0_n4401# surfaceTestElement_24/m4_n4402_n600#
+ surfaceTestElement_1/m3_n3000_n4401# surfaceTestElement_1/m3_1000_n4401# surfaceTestElement_1/m3_n4000_n4401#
+ surfaceTestElement_24/m4_n4402_800# surfaceTestElement_24/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_42 surfaceTestElement_9/m3_n1000_n4401# surfaceTestElement_49/m4_n4402_n1200#
+ surfaceTestElement_9/m3_n2000_n4401# surfaceTestElement_9/m3_0_n4401# surfaceTestElement_49/m4_n4402_n600#
+ surfaceTestElement_9/m3_n3000_n4401# surfaceTestElement_9/m3_1000_n4401# surfaceTestElement_9/m3_n4000_n4401#
+ surfaceTestElement_49/m4_n4402_800# surfaceTestElement_49/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_31 surfaceTestElement_0/m3_n1000_n4401# surfaceTestElement_48/m4_n4402_n1200#
+ surfaceTestElement_0/m3_n2000_n4401# surfaceTestElement_0/m3_0_n4401# surfaceTestElement_48/m4_n4402_n600#
+ surfaceTestElement_0/m3_n3000_n4401# surfaceTestElement_0/m3_1000_n4401# surfaceTestElement_0/m3_n4000_n4401#
+ surfaceTestElement_48/m4_n4402_800# surfaceTestElement_48/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_10 surfaceTestElement_47/m3_n1000_n4401# surfaceTestElement_9/m4_n4402_n1200#
+ surfaceTestElement_47/m3_n2000_n4401# surfaceTestElement_47/m3_0_n4401# surfaceTestElement_9/m4_n4402_n600#
+ surfaceTestElement_47/m3_n3000_n4401# surfaceTestElement_47/m3_1000_n4401# surfaceTestElement_47/m3_n4000_n4401#
+ surfaceTestElement_9/m4_n4402_800# surfaceTestElement_9/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_21 surfaceTestElement_0/m3_n1000_n4401# surfaceTestElement_24/m4_n4402_n1200#
+ surfaceTestElement_0/m3_n2000_n4401# surfaceTestElement_0/m3_0_n4401# surfaceTestElement_24/m4_n4402_n600#
+ surfaceTestElement_0/m3_n3000_n4401# surfaceTestElement_0/m3_1000_n4401# surfaceTestElement_0/m3_n4000_n4401#
+ surfaceTestElement_24/m4_n4402_800# surfaceTestElement_24/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_43 surfaceTestElement_9/m3_n1000_n4401# surfaceTestElement_48/m4_n4402_n1200#
+ surfaceTestElement_9/m3_n2000_n4401# surfaceTestElement_9/m3_0_n4401# surfaceTestElement_48/m4_n4402_n600#
+ surfaceTestElement_9/m3_n3000_n4401# surfaceTestElement_9/m3_1000_n4401# surfaceTestElement_9/m3_n4000_n4401#
+ surfaceTestElement_48/m4_n4402_800# surfaceTestElement_48/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_32 surfaceTestElement_1/m3_n1000_n4401# surfaceTestElement_49/m4_n4402_n1200#
+ surfaceTestElement_1/m3_n2000_n4401# surfaceTestElement_1/m3_0_n4401# surfaceTestElement_49/m4_n4402_n600#
+ surfaceTestElement_1/m3_n3000_n4401# surfaceTestElement_1/m3_1000_n4401# surfaceTestElement_1/m3_n4000_n4401#
+ surfaceTestElement_49/m4_n4402_800# surfaceTestElement_49/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_11 surfaceTestElement_45/m3_n1000_n4401# surfaceTestElement_9/m4_n4402_n1200#
+ surfaceTestElement_45/m3_n2000_n4401# surfaceTestElement_45/m3_0_n4401# surfaceTestElement_9/m4_n4402_n600#
+ surfaceTestElement_45/m3_n3000_n4401# surfaceTestElement_45/m3_1000_n4401# surfaceTestElement_45/m3_n4000_n4401#
+ surfaceTestElement_9/m4_n4402_800# surfaceTestElement_9/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_22 surfaceTestElement_6/m3_n1000_n4401# surfaceTestElement_24/m4_n4402_n1200#
+ surfaceTestElement_6/m3_n2000_n4401# surfaceTestElement_6/m3_0_n4401# surfaceTestElement_24/m4_n4402_n600#
+ surfaceTestElement_6/m3_n3000_n4401# surfaceTestElement_6/m3_1000_n4401# surfaceTestElement_6/m3_n4000_n4401#
+ surfaceTestElement_24/m4_n4402_800# surfaceTestElement_24/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_44 surfaceTestElement_45/m3_n1000_n4401# surfaceTestElement_49/m4_n4402_n1200#
+ surfaceTestElement_45/m3_n2000_n4401# surfaceTestElement_45/m3_0_n4401# surfaceTestElement_49/m4_n4402_n600#
+ surfaceTestElement_45/m3_n3000_n4401# surfaceTestElement_45/m3_1000_n4401# surfaceTestElement_45/m3_n4000_n4401#
+ surfaceTestElement_49/m4_n4402_800# surfaceTestElement_49/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_33 surfaceTestElement_1/m3_n1000_n4401# surfaceTestElement_48/m4_n4402_n1200#
+ surfaceTestElement_1/m3_n2000_n4401# surfaceTestElement_1/m3_0_n4401# surfaceTestElement_48/m4_n4402_n600#
+ surfaceTestElement_1/m3_n3000_n4401# surfaceTestElement_1/m3_1000_n4401# surfaceTestElement_1/m3_n4000_n4401#
+ surfaceTestElement_48/m4_n4402_800# surfaceTestElement_48/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_24 surfaceTestElement_47/m3_n1000_n4401# surfaceTestElement_24/m4_n4402_n1200#
+ surfaceTestElement_47/m3_n2000_n4401# surfaceTestElement_47/m3_0_n4401# surfaceTestElement_24/m4_n4402_n600#
+ surfaceTestElement_47/m3_n3000_n4401# surfaceTestElement_47/m3_1000_n4401# surfaceTestElement_47/m3_n4000_n4401#
+ surfaceTestElement_24/m4_n4402_800# surfaceTestElement_24/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_23 surfaceTestElement_9/m3_n1000_n4401# surfaceTestElement_24/m4_n4402_n1200#
+ surfaceTestElement_9/m3_n2000_n4401# surfaceTestElement_9/m3_0_n4401# surfaceTestElement_24/m4_n4402_n600#
+ surfaceTestElement_9/m3_n3000_n4401# surfaceTestElement_9/m3_1000_n4401# surfaceTestElement_9/m3_n4000_n4401#
+ surfaceTestElement_24/m4_n4402_800# surfaceTestElement_24/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_13 surfaceTestElement_7/m3_n1000_n4401# surfaceTestElement_24/m4_n4402_n1200#
+ surfaceTestElement_7/m3_n2000_n4401# surfaceTestElement_7/m3_0_n4401# surfaceTestElement_24/m4_n4402_n600#
+ surfaceTestElement_7/m3_n3000_n4401# surfaceTestElement_7/m3_1000_n4401# surfaceTestElement_7/m3_n4000_n4401#
+ surfaceTestElement_24/m4_n4402_800# surfaceTestElement_24/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_12 surfaceTestElement_8/m3_n1000_n4401# surfaceTestElement_24/m4_n4402_n1200#
+ surfaceTestElement_8/m3_n2000_n4401# surfaceTestElement_8/m3_0_n4401# surfaceTestElement_24/m4_n4402_n600#
+ surfaceTestElement_8/m3_n3000_n4401# surfaceTestElement_8/m3_1000_n4401# surfaceTestElement_8/m3_n4000_n4401#
+ surfaceTestElement_24/m4_n4402_800# surfaceTestElement_24/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_46 surfaceTestElement_47/m3_n1000_n4401# surfaceTestElement_49/m4_n4402_n1200#
+ surfaceTestElement_47/m3_n2000_n4401# surfaceTestElement_47/m3_0_n4401# surfaceTestElement_49/m4_n4402_n600#
+ surfaceTestElement_47/m3_n3000_n4401# surfaceTestElement_47/m3_1000_n4401# surfaceTestElement_47/m3_n4000_n4401#
+ surfaceTestElement_49/m4_n4402_800# surfaceTestElement_49/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_45 surfaceTestElement_45/m3_n1000_n4401# surfaceTestElement_48/m4_n4402_n1200#
+ surfaceTestElement_45/m3_n2000_n4401# surfaceTestElement_45/m3_0_n4401# surfaceTestElement_48/m4_n4402_n600#
+ surfaceTestElement_45/m3_n3000_n4401# surfaceTestElement_45/m3_1000_n4401# surfaceTestElement_45/m3_n4000_n4401#
+ surfaceTestElement_48/m4_n4402_800# surfaceTestElement_48/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_34 surfaceTestElement_4/m3_n1000_n4401# surfaceTestElement_48/m4_n4402_n1200#
+ surfaceTestElement_4/m3_n2000_n4401# surfaceTestElement_4/m3_0_n4401# surfaceTestElement_48/m4_n4402_n600#
+ surfaceTestElement_4/m3_n3000_n4401# surfaceTestElement_4/m3_1000_n4401# surfaceTestElement_4/m3_n4000_n4401#
+ surfaceTestElement_48/m4_n4402_800# surfaceTestElement_48/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_35 surfaceTestElement_4/m3_n1000_n4401# surfaceTestElement_49/m4_n4402_n1200#
+ surfaceTestElement_4/m3_n2000_n4401# surfaceTestElement_4/m3_0_n4401# surfaceTestElement_49/m4_n4402_n600#
+ surfaceTestElement_4/m3_n3000_n4401# surfaceTestElement_4/m3_1000_n4401# surfaceTestElement_4/m3_n4000_n4401#
+ surfaceTestElement_49/m4_n4402_800# surfaceTestElement_49/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_25 surfaceTestElement_1/m3_n1000_n4401# surfaceTestElement_4/m4_n4402_n1200#
+ surfaceTestElement_1/m3_n2000_n4401# surfaceTestElement_1/m3_0_n4401# surfaceTestElement_4/m4_n4402_n600#
+ surfaceTestElement_1/m3_n3000_n4401# surfaceTestElement_1/m3_1000_n4401# surfaceTestElement_1/m3_n4000_n4401#
+ surfaceTestElement_4/m4_n4402_800# surfaceTestElement_4/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_14 surfaceTestElement_45/m3_n1000_n4401# surfaceTestElement_24/m4_n4402_n1200#
+ surfaceTestElement_45/m3_n2000_n4401# surfaceTestElement_45/m3_0_n4401# surfaceTestElement_24/m4_n4402_n600#
+ surfaceTestElement_45/m3_n3000_n4401# surfaceTestElement_45/m3_1000_n4401# surfaceTestElement_45/m3_n4000_n4401#
+ surfaceTestElement_24/m4_n4402_800# surfaceTestElement_24/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_47 surfaceTestElement_47/m3_n1000_n4401# surfaceTestElement_48/m4_n4402_n1200#
+ surfaceTestElement_47/m3_n2000_n4401# surfaceTestElement_47/m3_0_n4401# surfaceTestElement_48/m4_n4402_n600#
+ surfaceTestElement_47/m3_n3000_n4401# surfaceTestElement_47/m3_1000_n4401# surfaceTestElement_47/m3_n4000_n4401#
+ surfaceTestElement_48/m4_n4402_800# surfaceTestElement_48/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_36 surfaceTestElement_8/m3_n1000_n4401# surfaceTestElement_49/m4_n4402_n1200#
+ surfaceTestElement_8/m3_n2000_n4401# surfaceTestElement_8/m3_0_n4401# surfaceTestElement_49/m4_n4402_n600#
+ surfaceTestElement_8/m3_n3000_n4401# surfaceTestElement_8/m3_1000_n4401# surfaceTestElement_8/m3_n4000_n4401#
+ surfaceTestElement_49/m4_n4402_800# surfaceTestElement_49/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_26 surfaceTestElement_0/m3_n1000_n4401# surfaceTestElement_4/m4_n4402_n1200#
+ surfaceTestElement_0/m3_n2000_n4401# surfaceTestElement_0/m3_0_n4401# surfaceTestElement_4/m4_n4402_n600#
+ surfaceTestElement_0/m3_n3000_n4401# surfaceTestElement_0/m3_1000_n4401# surfaceTestElement_0/m3_n4000_n4401#
+ surfaceTestElement_4/m4_n4402_800# surfaceTestElement_4/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_15 surfaceTestElement_5/m3_n1000_n4401# surfaceTestElement_24/m4_n4402_n1200#
+ surfaceTestElement_5/m3_n2000_n4401# surfaceTestElement_5/m3_0_n4401# surfaceTestElement_24/m4_n4402_n600#
+ surfaceTestElement_5/m3_n3000_n4401# surfaceTestElement_5/m3_1000_n4401# surfaceTestElement_5/m3_n4000_n4401#
+ surfaceTestElement_24/m4_n4402_800# surfaceTestElement_24/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_48 surfaceTestElement_5/m3_n1000_n4401# surfaceTestElement_48/m4_n4402_n1200#
+ surfaceTestElement_5/m3_n2000_n4401# surfaceTestElement_5/m3_0_n4401# surfaceTestElement_48/m4_n4402_n600#
+ surfaceTestElement_5/m3_n3000_n4401# surfaceTestElement_5/m3_1000_n4401# surfaceTestElement_5/m3_n4000_n4401#
+ surfaceTestElement_48/m4_n4402_800# surfaceTestElement_48/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_37 surfaceTestElement_8/m3_n1000_n4401# surfaceTestElement_48/m4_n4402_n1200#
+ surfaceTestElement_8/m3_n2000_n4401# surfaceTestElement_8/m3_0_n4401# surfaceTestElement_48/m4_n4402_n600#
+ surfaceTestElement_8/m3_n3000_n4401# surfaceTestElement_8/m3_1000_n4401# surfaceTestElement_8/m3_n4000_n4401#
+ surfaceTestElement_48/m4_n4402_800# surfaceTestElement_48/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_27 surfaceTestElement_6/m3_n1000_n4401# surfaceTestElement_4/m4_n4402_n1200#
+ surfaceTestElement_6/m3_n2000_n4401# surfaceTestElement_6/m3_0_n4401# surfaceTestElement_4/m4_n4402_n600#
+ surfaceTestElement_6/m3_n3000_n4401# surfaceTestElement_6/m3_1000_n4401# surfaceTestElement_6/m3_n4000_n4401#
+ surfaceTestElement_4/m4_n4402_800# surfaceTestElement_4/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_16 surfaceTestElement_4/m3_n1000_n4401# surfaceTestElement_24/m4_n4402_n1200#
+ surfaceTestElement_4/m3_n2000_n4401# surfaceTestElement_4/m3_0_n4401# surfaceTestElement_24/m4_n4402_n600#
+ surfaceTestElement_4/m3_n3000_n4401# surfaceTestElement_4/m3_1000_n4401# surfaceTestElement_4/m3_n4000_n4401#
+ surfaceTestElement_24/m4_n4402_800# surfaceTestElement_24/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_49 surfaceTestElement_5/m3_n1000_n4401# surfaceTestElement_49/m4_n4402_n1200#
+ surfaceTestElement_5/m3_n2000_n4401# surfaceTestElement_5/m3_0_n4401# surfaceTestElement_49/m4_n4402_n600#
+ surfaceTestElement_5/m3_n3000_n4401# surfaceTestElement_5/m3_1000_n4401# surfaceTestElement_5/m3_n4000_n4401#
+ surfaceTestElement_49/m4_n4402_800# surfaceTestElement_49/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_38 surfaceTestElement_6/m3_n1000_n4401# surfaceTestElement_49/m4_n4402_n1200#
+ surfaceTestElement_6/m3_n2000_n4401# surfaceTestElement_6/m3_0_n4401# surfaceTestElement_49/m4_n4402_n600#
+ surfaceTestElement_6/m3_n3000_n4401# surfaceTestElement_6/m3_1000_n4401# surfaceTestElement_6/m3_n4000_n4401#
+ surfaceTestElement_49/m4_n4402_800# surfaceTestElement_49/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_28 surfaceTestElement_47/m3_n1000_n4401# surfaceTestElement_4/m4_n4402_n1200#
+ surfaceTestElement_47/m3_n2000_n4401# surfaceTestElement_47/m3_0_n4401# surfaceTestElement_4/m4_n4402_n600#
+ surfaceTestElement_47/m3_n3000_n4401# surfaceTestElement_47/m3_1000_n4401# surfaceTestElement_47/m3_n4000_n4401#
+ surfaceTestElement_4/m4_n4402_800# surfaceTestElement_4/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_17 surfaceTestElement_8/m3_n1000_n4401# surfaceTestElement_4/m4_n4402_n1200#
+ surfaceTestElement_8/m3_n2000_n4401# surfaceTestElement_8/m3_0_n4401# surfaceTestElement_4/m4_n4402_n600#
+ surfaceTestElement_8/m3_n3000_n4401# surfaceTestElement_8/m3_1000_n4401# surfaceTestElement_8/m3_n4000_n4401#
+ surfaceTestElement_4/m4_n4402_800# surfaceTestElement_4/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_39 surfaceTestElement_6/m3_n1000_n4401# surfaceTestElement_48/m4_n4402_n1200#
+ surfaceTestElement_6/m3_n2000_n4401# surfaceTestElement_6/m3_0_n4401# surfaceTestElement_48/m4_n4402_n600#
+ surfaceTestElement_6/m3_n3000_n4401# surfaceTestElement_6/m3_1000_n4401# surfaceTestElement_6/m3_n4000_n4401#
+ surfaceTestElement_48/m4_n4402_800# surfaceTestElement_48/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_0 surfaceTestElement_0/m3_n1000_n4401# surfaceTestElement_9/m4_n4402_n1200#
+ surfaceTestElement_0/m3_n2000_n4401# surfaceTestElement_0/m3_0_n4401# surfaceTestElement_9/m4_n4402_n600#
+ surfaceTestElement_0/m3_n3000_n4401# surfaceTestElement_0/m3_1000_n4401# surfaceTestElement_0/m3_n4000_n4401#
+ surfaceTestElement_9/m4_n4402_800# surfaceTestElement_9/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_18 surfaceTestElement_45/m3_n1000_n4401# surfaceTestElement_4/m4_n4402_n1200#
+ surfaceTestElement_45/m3_n2000_n4401# surfaceTestElement_45/m3_0_n4401# surfaceTestElement_4/m4_n4402_n600#
+ surfaceTestElement_45/m3_n3000_n4401# surfaceTestElement_45/m3_1000_n4401# surfaceTestElement_45/m3_n4000_n4401#
+ surfaceTestElement_4/m4_n4402_800# surfaceTestElement_4/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_29 surfaceTestElement_9/m3_n1000_n4401# surfaceTestElement_4/m4_n4402_n1200#
+ surfaceTestElement_9/m3_n2000_n4401# surfaceTestElement_9/m3_0_n4401# surfaceTestElement_4/m4_n4402_n600#
+ surfaceTestElement_9/m3_n3000_n4401# surfaceTestElement_9/m3_1000_n4401# surfaceTestElement_9/m3_n4000_n4401#
+ surfaceTestElement_4/m4_n4402_800# surfaceTestElement_4/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_1 surfaceTestElement_1/m3_n1000_n4401# surfaceTestElement_9/m4_n4402_n1200#
+ surfaceTestElement_1/m3_n2000_n4401# surfaceTestElement_1/m3_0_n4401# surfaceTestElement_9/m4_n4402_n600#
+ surfaceTestElement_1/m3_n3000_n4401# surfaceTestElement_1/m3_1000_n4401# surfaceTestElement_1/m3_n4000_n4401#
+ surfaceTestElement_9/m4_n4402_800# surfaceTestElement_9/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_19 surfaceTestElement_7/m3_n1000_n4401# surfaceTestElement_4/m4_n4402_n1200#
+ surfaceTestElement_7/m3_n2000_n4401# surfaceTestElement_7/m3_0_n4401# surfaceTestElement_4/m4_n4402_n600#
+ surfaceTestElement_7/m3_n3000_n4401# surfaceTestElement_7/m3_1000_n4401# surfaceTestElement_7/m3_n4000_n4401#
+ surfaceTestElement_4/m4_n4402_800# surfaceTestElement_4/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_2 surfaceTestElement_4/m3_n1000_n4401# surfaceTestElement_9/m4_n4402_n1200#
+ surfaceTestElement_4/m3_n2000_n4401# surfaceTestElement_4/m3_0_n4401# surfaceTestElement_9/m4_n4402_n600#
+ surfaceTestElement_4/m3_n3000_n4401# surfaceTestElement_4/m3_1000_n4401# surfaceTestElement_4/m3_n4000_n4401#
+ surfaceTestElement_9/m4_n4402_800# surfaceTestElement_9/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_3 surfaceTestElement_5/m3_n1000_n4401# surfaceTestElement_4/m4_n4402_n1200#
+ surfaceTestElement_5/m3_n2000_n4401# surfaceTestElement_5/m3_0_n4401# surfaceTestElement_4/m4_n4402_n600#
+ surfaceTestElement_5/m3_n3000_n4401# surfaceTestElement_5/m3_1000_n4401# surfaceTestElement_5/m3_n4000_n4401#
+ surfaceTestElement_4/m4_n4402_800# surfaceTestElement_4/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_4 surfaceTestElement_4/m3_n1000_n4401# surfaceTestElement_4/m4_n4402_n1200#
+ surfaceTestElement_4/m3_n2000_n4401# surfaceTestElement_4/m3_0_n4401# surfaceTestElement_4/m4_n4402_n600#
+ surfaceTestElement_4/m3_n3000_n4401# surfaceTestElement_4/m3_1000_n4401# surfaceTestElement_4/m3_n4000_n4401#
+ surfaceTestElement_4/m4_n4402_800# surfaceTestElement_4/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_5 surfaceTestElement_5/m3_n1000_n4401# surfaceTestElement_9/m4_n4402_n1200#
+ surfaceTestElement_5/m3_n2000_n4401# surfaceTestElement_5/m3_0_n4401# surfaceTestElement_9/m4_n4402_n600#
+ surfaceTestElement_5/m3_n3000_n4401# surfaceTestElement_5/m3_1000_n4401# surfaceTestElement_5/m3_n4000_n4401#
+ surfaceTestElement_9/m4_n4402_800# surfaceTestElement_9/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_6 surfaceTestElement_6/m3_n1000_n4401# surfaceTestElement_9/m4_n4402_n1200#
+ surfaceTestElement_6/m3_n2000_n4401# surfaceTestElement_6/m3_0_n4401# surfaceTestElement_9/m4_n4402_n600#
+ surfaceTestElement_6/m3_n3000_n4401# surfaceTestElement_6/m3_1000_n4401# surfaceTestElement_6/m3_n4000_n4401#
+ surfaceTestElement_9/m4_n4402_800# surfaceTestElement_9/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_7 surfaceTestElement_7/m3_n1000_n4401# surfaceTestElement_9/m4_n4402_n1200#
+ surfaceTestElement_7/m3_n2000_n4401# surfaceTestElement_7/m3_0_n4401# surfaceTestElement_9/m4_n4402_n600#
+ surfaceTestElement_7/m3_n3000_n4401# surfaceTestElement_7/m3_1000_n4401# surfaceTestElement_7/m3_n4000_n4401#
+ surfaceTestElement_9/m4_n4402_800# surfaceTestElement_9/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_8 surfaceTestElement_8/m3_n1000_n4401# surfaceTestElement_9/m4_n4402_n1200#
+ surfaceTestElement_8/m3_n2000_n4401# surfaceTestElement_8/m3_0_n4401# surfaceTestElement_9/m4_n4402_n600#
+ surfaceTestElement_8/m3_n3000_n4401# surfaceTestElement_8/m3_1000_n4401# surfaceTestElement_8/m3_n4000_n4401#
+ surfaceTestElement_9/m4_n4402_800# surfaceTestElement_9/m4_n4402_200# surfaceTestElement
XsurfaceTestElement_9 surfaceTestElement_9/m3_n1000_n4401# surfaceTestElement_9/m4_n4402_n1200#
+ surfaceTestElement_9/m3_n2000_n4401# surfaceTestElement_9/m3_0_n4401# surfaceTestElement_9/m4_n4402_n600#
+ surfaceTestElement_9/m3_n3000_n4401# surfaceTestElement_9/m3_1000_n4401# surfaceTestElement_9/m3_n4000_n4401#
+ surfaceTestElement_9/m4_n4402_800# surfaceTestElement_9/m4_n4402_200# surfaceTestElement
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$2 a_n500_n138# a_500_n50# a_n692_n272# a_n558_n50#
X0 a_500_n50# a_n500_n138# a_n558_n50# a_n692_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=5e+06u
.ends

.subckt w50_l500_nmos sky130_fd_pr__nfet_g5v0d10v5$2_0/a_500_n50# sky130_fd_pr__nfet_g5v0d10v5$2_0/a_n500_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$2_0/a_n558_n50# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$2_0 sky130_fd_pr__nfet_g5v0d10v5$2_0/a_n500_n138# sky130_fd_pr__nfet_g5v0d10v5$2_0/a_500_n50#
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5$2_0/a_n558_n50# sky130_fd_pr__nfet_g5v0d10v5$2
.ends

.subckt x1T1R_w50_l500_nmos B D DIODE RRAM$2_0/VSUBS
Xw50_l500_nmos_0 D w_5419_n25463# m1_n18719_n21695# RRAM$2_0/VSUBS w50_l500_nmos
D0 RRAM$2_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$1$3 a_1000_n50# w_n1258_n347# a_n1000_n147# a_n1058_n50#
X0 a_1000_n50# a_n1000_n147# a_n1058_n50# w_n1258_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+07u
.ends

.subckt w50_l1000_pmos$1 sky130_fd_pr__pfet_g5v0d10v5$1$3_0/w_n1258_n347# sky130_fd_pr__pfet_g5v0d10v5$1$3_0/a_n1000_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$1$3_0/a_n1058_n50# sky130_fd_pr__pfet_g5v0d10v5$1$3_0/a_1000_n50#
Xsky130_fd_pr__pfet_g5v0d10v5$1$3_0 sky130_fd_pr__pfet_g5v0d10v5$1$3_0/a_1000_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$1$3_0/w_n1258_n347# sky130_fd_pr__pfet_g5v0d10v5$1$3_0/a_n1000_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$1$3_0/a_n1058_n50# sky130_fd_pr__pfet_g5v0d10v5$1$3
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$1$2 a_n1000_n138# a_n1192_n272# a_n1058_n50#
X0 a_1000_n50# a_n1000_n138# a_n1058_n50# a_n1192_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+07u
.ends

.subckt w50_l1000_nmos$1 sky130_fd_pr__nfet_g5v0d10v5$1$2_0/a_n1000_n138# sky130_fd_pr__nfet_g5v0d10v5$1$2_0/a_n1058_n50#
+ VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$1$2_0 sky130_fd_pr__nfet_g5v0d10v5$1$2_0/a_n1000_n138#
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5$1$2_0/a_n1058_n50# sky130_fd_pr__nfet_g5v0d10v5$1$2
.ends

.subckt x2T1R_w50_l1000 G_n G_p DIODE_p DIODE_n B_n B_p D RRAM$4$5_0/VSUBS
Xw50_l1000_pmos$1_0 li_n19119_n18569# w_41419_n25463# D m1_n18719_n20953# w50_l1000_pmos$1
Xw50_l1000_nmos$1_0 w_5419_n25463# m1_n18719_n20953# RRAM$4$5_0/VSUBS w50_l1000_nmos$1
D0 RRAM$4$5_0/VSUBS w_41419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
D1 RRAM$4$5_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$4 a_100_n50# a_n100_n138# a_n158_n50# a_n292_n272#
X0 a_100_n50# a_n100_n138# a_n158_n50# a_n292_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+06u
.ends

.subckt w50_l100_nmos sky130_fd_pr__nfet_g5v0d10v5$4_0/a_n158_n50# sky130_fd_pr__nfet_g5v0d10v5$4_0/a_100_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$4_0/a_n100_n138# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$4_0 sky130_fd_pr__nfet_g5v0d10v5$4_0/a_100_n50# sky130_fd_pr__nfet_g5v0d10v5$4_0/a_n100_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$4_0/a_n158_n50# VSUBS sky130_fd_pr__nfet_g5v0d10v5$4
.ends

.subckt x1T1R_w50_l100_nmos DIODE D B RRAM$4_0/VSUBS
Xw50_l100_nmos_0 m1_n18719_n22101# D w_5419_n25463# RRAM$4_0/VSUBS w50_l100_nmos
D0 RRAM$4_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$1$1 a_n500_n138# a_500_n50# a_n692_n272# a_n558_n50#
X0 a_500_n50# a_n500_n138# a_n558_n50# a_n692_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=5e+06u
.ends

.subckt w50_l500_nmos$1 sky130_fd_pr__nfet_g5v0d10v5$1$1_0/a_500_n50# sky130_fd_pr__nfet_g5v0d10v5$1$1_0/a_n558_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$1$1_0/a_n500_n138# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$1$1_0 sky130_fd_pr__nfet_g5v0d10v5$1$1_0/a_n500_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$1$1_0/a_500_n50# VSUBS sky130_fd_pr__nfet_g5v0d10v5$1$1_0/a_n558_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$1$1
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$1$2 w_n758_n347# a_500_n50# a_n500_n147# a_n558_n50#
X0 a_500_n50# a_n500_n147# a_n558_n50# w_n758_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=5e+06u
.ends

.subckt w50_l500_pmos$1 sky130_fd_pr__pfet_g5v0d10v5$1$2_0/a_n500_n147# sky130_fd_pr__pfet_g5v0d10v5$1$2_0/a_500_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$1$2_0/w_n758_n347# sky130_fd_pr__pfet_g5v0d10v5$1$2_0/a_n558_n50#
Xsky130_fd_pr__pfet_g5v0d10v5$1$2_0 sky130_fd_pr__pfet_g5v0d10v5$1$2_0/w_n758_n347#
+ sky130_fd_pr__pfet_g5v0d10v5$1$2_0/a_500_n50# sky130_fd_pr__pfet_g5v0d10v5$1$2_0/a_n500_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$1$2_0/a_n558_n50# sky130_fd_pr__pfet_g5v0d10v5$1$2
.ends

.subckt x2T1R_w50_l500 G_n G_p DIODE_p DIODE_n B_n B_p D RRAM$4$3_0/VSUBS
Xw50_l500_nmos$1_0 D m1_n18719_n21803# w_5419_n25463# RRAM$4$3_0/VSUBS w50_l500_nmos$1
Xw50_l500_pmos$1_0 w_41419_n25463# m1_n18719_n21803# li_n19119_n20673# D w50_l500_pmos$1
D0 RRAM$4$3_0/VSUBS w_41419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
D1 RRAM$4$3_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$1$1 w_n758_n347# a_500_n50# a_n500_n147# a_n558_n50#
X0 a_500_n50# a_n500_n147# a_n558_n50# w_n758_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=5e+06u
.ends

.subckt w50_l500_pmos sky130_fd_pr__pfet_g5v0d10v5$1$1_0/a_n558_n50# sky130_fd_pr__pfet_g5v0d10v5$1$1_0/a_500_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$1$1_0/a_n500_n147# sky130_fd_pr__pfet_g5v0d10v5$1$1_0/w_n758_n347#
Xsky130_fd_pr__pfet_g5v0d10v5$1$1_0 sky130_fd_pr__pfet_g5v0d10v5$1$1_0/w_n758_n347#
+ sky130_fd_pr__pfet_g5v0d10v5$1$1_0/a_500_n50# sky130_fd_pr__pfet_g5v0d10v5$1$1_0/a_n500_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$1$1_0/a_n558_n50# sky130_fd_pr__pfet_g5v0d10v5$1$1
.ends

.subckt x1T1R_w50_l500_pmos B D DIODE
Xw50_l500_pmos_0 RRAM$8_0/TE D w_5419_n25463# li_n19119_n22791# w50_l500_pmos
D0 RRAM$8_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5 a_n1000_n138# a_1000_n50# a_n1192_n272# a_n1058_n50#
X0 a_1000_n50# a_n1000_n138# a_n1058_n50# a_n1192_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+07u
.ends

.subckt w50_l1000_nmos sky130_fd_pr__nfet_g5v0d10v5_0/a_1000_n50# sky130_fd_pr__nfet_g5v0d10v5_0/a_n1000_n138#
+ sky130_fd_pr__nfet_g5v0d10v5_0/a_n1058_n50# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5_0 sky130_fd_pr__nfet_g5v0d10v5_0/a_n1000_n138# sky130_fd_pr__nfet_g5v0d10v5_0/a_1000_n50#
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5_0/a_n1058_n50# sky130_fd_pr__nfet_g5v0d10v5
.ends

.subckt x1T1R_w50_l1000_nmos B D DIODE RRAM$5_0/VSUBS
Xw50_l1000_nmos_0 D w_5419_n25463# m1_n18719_n21199# RRAM$5_0/VSUBS w50_l1000_nmos
D0 RRAM$5_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5 w_n358_n347# a_100_n50# a_n158_n50# a_n100_n147#
X0 a_100_n50# a_n100_n147# a_n158_n50# w_n358_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+06u
.ends

.subckt w50_l100_pmos sky130_fd_pr__pfet_g5v0d10v5_0/a_n100_n147# sky130_fd_pr__pfet_g5v0d10v5_0/a_100_n50#
+ sky130_fd_pr__pfet_g5v0d10v5_0/w_n358_n347# sky130_fd_pr__pfet_g5v0d10v5_0/a_n158_n50#
Xsky130_fd_pr__pfet_g5v0d10v5_0 sky130_fd_pr__pfet_g5v0d10v5_0/w_n358_n347# sky130_fd_pr__pfet_g5v0d10v5_0/a_100_n50#
+ sky130_fd_pr__pfet_g5v0d10v5_0/a_n158_n50# sky130_fd_pr__pfet_g5v0d10v5_0/a_n100_n147#
+ sky130_fd_pr__pfet_g5v0d10v5
.ends

.subckt x1T1R_w50_l100_pmos B D DIODE
Xw50_l100_pmos_0 w_5419_n25463# D li_n19119_n22791# RRAM$6_0/TE w50_l100_pmos
D0 RRAM$6_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$4$1 a_100_n50# a_n100_n138# a_n158_n50# a_n292_n272#
X0 a_100_n50# a_n100_n138# a_n158_n50# a_n292_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+06u
.ends

.subckt w50_l100_nmos$1 sky130_fd_pr__nfet_g5v0d10v5$4$1_0/a_n158_n50# sky130_fd_pr__nfet_g5v0d10v5$4$1_0/a_n100_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$4$1_0/a_100_n50# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$4$1_0 sky130_fd_pr__nfet_g5v0d10v5$4$1_0/a_100_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$4$1_0/a_n100_n138# sky130_fd_pr__nfet_g5v0d10v5$4$1_0/a_n158_n50#
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5$4$1
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5_AQFHUS w_n358_n347# a_100_n50# a_n158_n50# a_n100_n147#
X0 a_100_n50# a_n100_n147# a_n158_n50# w_n358_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+06u
.ends

.subckt w50_l100_pmos$1 sky130_fd_pr__pfet_g5v0d10v5_AQFHUS_0/a_100_n50# sky130_fd_pr__pfet_g5v0d10v5_AQFHUS_0/a_n100_n147#
+ sky130_fd_pr__pfet_g5v0d10v5_AQFHUS_0/w_n358_n347# sky130_fd_pr__pfet_g5v0d10v5_AQFHUS_0/a_n158_n50#
Xsky130_fd_pr__pfet_g5v0d10v5_AQFHUS_0 sky130_fd_pr__pfet_g5v0d10v5_AQFHUS_0/w_n358_n347#
+ sky130_fd_pr__pfet_g5v0d10v5_AQFHUS_0/a_100_n50# sky130_fd_pr__pfet_g5v0d10v5_AQFHUS_0/a_n158_n50#
+ sky130_fd_pr__pfet_g5v0d10v5_AQFHUS_0/a_n100_n147# sky130_fd_pr__pfet_g5v0d10v5_AQFHUS
.ends

.subckt x2T1R_w50_l100 G_n G_p DIODE_p DIODE_n B_n B_p D RRAM$4$1_0/VSUBS
Xw50_l100_nmos$1_0 m1_n18719_n22101# w_5419_n25463# D RRAM$4$1_0/VSUBS w50_l100_nmos$1
Xw50_l100_pmos$1_0 m1_n18719_n22101# w_41419_n25463# li_n19119_n20775# D w50_l100_pmos$1
D0 RRAM$4$1_0/VSUBS w_41419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
D1 RRAM$4$1_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$3 a_1000_n50# w_n1258_n347# a_n1000_n147# a_n1058_n50#
X0 a_1000_n50# a_n1000_n147# a_n1058_n50# w_n1258_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+07u
.ends

.subckt w50_l1000_pmos sky130_fd_pr__pfet_g5v0d10v5$3_0/a_1000_n50# sky130_fd_pr__pfet_g5v0d10v5$3_0/w_n1258_n347#
+ sky130_fd_pr__pfet_g5v0d10v5$3_0/a_n1058_n50# sky130_fd_pr__pfet_g5v0d10v5$3_0/a_n1000_n147#
Xsky130_fd_pr__pfet_g5v0d10v5$3_0 sky130_fd_pr__pfet_g5v0d10v5$3_0/a_1000_n50# sky130_fd_pr__pfet_g5v0d10v5$3_0/w_n1258_n347#
+ sky130_fd_pr__pfet_g5v0d10v5$3_0/a_n1000_n147# sky130_fd_pr__pfet_g5v0d10v5$3_0/a_n1058_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$3
.ends

.subckt x1T1R_w50_l1000_pmos B D DIODE
Xw50_l1000_pmos_0 D li_n19119_n22791# RRAM$10_0/TE w_5419_n25463# w50_l1000_pmos
D0 RRAM$10_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt MPW7_GWU Vb_2 vgnd Vdd Vb_1 G_2 G_1 TE x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS DIODE_2
+ DIODE_1
Xx1T1R_w50_l500_nmos_0 x1T1R_w50_l500_nmos_0/B x1T1R_w50_l500_nmos_0/D x1T1R_w50_l500_nmos_0/DIODE
+ x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS x1T1R_w50_l500_nmos
Xx2T1R_w50_l1000_0 x2T1R_w50_l1000_0/G_n x2T1R_w50_l1000_0/G_p x2T1R_w50_l1000_0/DIODE_p
+ x2T1R_w50_l1000_0/DIODE_n x2T1R_w50_l1000_0/B_n x2T1R_w50_l1000_0/B_p x2T1R_w50_l1000_0/D
+ x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS x2T1R_w50_l1000
Xx1T1R_w50_l100_nmos_0 x1T1R_w50_l100_nmos_0/DIODE x1T1R_w50_l100_nmos_0/D x1T1R_w50_l100_nmos_0/B
+ x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS x1T1R_w50_l100_nmos
Xx2T1R_w50_l500_0 x2T1R_w50_l500_0/G_n x2T1R_w50_l500_0/G_p x2T1R_w50_l500_0/DIODE_p
+ x2T1R_w50_l500_0/DIODE_n x2T1R_w50_l500_0/B_n x2T1R_w50_l500_0/B_p x2T1R_w50_l500_0/D
+ x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS x2T1R_w50_l500
Xx1T1R_w50_l500_pmos_0 x1T1R_w50_l500_pmos_0/B x1T1R_w50_l500_pmos_0/D x1T1R_w50_l500_pmos_0/DIODE
+ x1T1R_w50_l500_pmos
Xx1T1R_w50_l1000_nmos_0 x1T1R_w50_l1000_nmos_0/B x1T1R_w50_l1000_nmos_0/D x1T1R_w50_l1000_nmos_0/DIODE
+ x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS x1T1R_w50_l1000_nmos
Xx1T1R_w50_l100_pmos_0 x1T1R_w50_l100_pmos_0/B x1T1R_w50_l100_pmos_0/D x1T1R_w50_l100_pmos_0/DIODE
+ x1T1R_w50_l100_pmos
Xx2T1R_w50_l100_0 x2T1R_w50_l100_0/G_n x2T1R_w50_l100_0/G_p x2T1R_w50_l100_0/DIODE_p
+ x2T1R_w50_l100_0/DIODE_n x2T1R_w50_l100_0/B_n x2T1R_w50_l100_0/B_p x2T1R_w50_l100_0/D
+ x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS x2T1R_w50_l100
Xx1T1R_w50_l1000_pmos_0 x1T1R_w50_l1000_pmos_0/B x1T1R_w50_l1000_pmos_0/D x1T1R_w50_l1000_pmos_0/DIODE
+ x1T1R_w50_l1000_pmos
D0 x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS DIODE_2 sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
X0 a_120368_n114099# TE x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS sky130_fd_pr__res_generic_nd w=420000u l=4.91336e+09u
D1 x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS DIODE_2 sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
D2 x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS DIODE_2 sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
X1 a_12219_n114222# DIODE_2 TE x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=2.03e+12p pd=1.458e+07u as=1.624e+13p ps=1.1664e+08u w=7e+06u l=500000u
X2 Vb_1 DIODE_1 TE x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=8.12e+12p pd=5.832e+07u as=0p ps=0u w=7e+06u l=500000u
X3 a_367_n114097# TE x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS sky130_fd_pr__res_generic_nd w=420000u l=4.91336e+09u
X4 a_120368_n114099# TE x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS sky130_fd_pr__res_generic_nd w=420000u l=4.91336e+09u
D3 x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS DIODE_1 sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
D4 x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS DIODE_1 sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
X5 Vb_1 DIODE_1 TE x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=7e+06u l=500000u
X6 a_367_n114097# TE x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS sky130_fd_pr__res_generic_nd w=420000u l=4.91336e+09u
X7 a_80368_n114099# TE x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS sky130_fd_pr__res_generic_nd w=420000u l=4.91336e+09u
X8 a_132220_n114224# DIODE_2 TE x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=2.03e+12p pd=1.458e+07u as=0p ps=0u w=7e+06u l=500000u
X9 a_92220_n114224# DIODE_2 TE x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=2.03e+12p pd=1.458e+07u as=0p ps=0u w=7e+06u l=500000u
D5 x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS DIODE_1 sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
X10 Vb_1 DIODE_1 TE x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=7e+06u l=500000u
X11 a_40368_n114097# TE x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS sky130_fd_pr__res_generic_nd w=420000u l=4.91336e+09u
X12 Vb_1 DIODE_1 TE x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=7e+06u l=500000u
D6 x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS DIODE_2 sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
D7 x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS DIODE_1 sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
X13 a_80368_n114099# TE x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS sky130_fd_pr__res_generic_nd w=420000u l=4.91336e+09u
X14 a_40368_n114097# TE x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS sky130_fd_pr__res_generic_nd w=420000u l=4.91336e+09u
X15 a_52220_n114222# DIODE_2 TE x2T1R_w50_l500_0/RRAM$4$3_0/VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=2.03e+12p pd=1.458e+07u as=0p ps=0u w=7e+06u l=500000u
.ends

.subckt TOP w_19531_382583# w_13120_646420# photo_V2_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-P-c
+ w_133616_36416# photo_V2_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-P-b w_133608_228340#
+ w_133616_339317# w_19531_370583# w_49012_658344# w_13120_634420# w_12912_502344#
+ w_49012_682344# w_133896_168596# w_133608_252340# w_49106_550390# w_19323_72340#
+ w_19711_334763# w_49012_670344# w_19431_202583# w_133608_240340# w_13300_598600#
+ w_19431_36416# photo_V2_1/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D3-P-b w_13020_466420#
+ photo_V3_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D3-P-b w_133716_216416# w_69508_375241#
+ photo_V4_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D5-P-c w_19423_418507# w_13012_658344#
+ photo_V2_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D3-P-b photo_V4_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D5-P-b
+ w_133716_204416# w_19517_286553# w_19423_406507# w_13106_550390# w_13012_682344#
+ w_13012_670344# w_133702_120386# w_69616_339317# w_101508_375241# w_49120_646420#
+ w_19423_394507# w_49120_634420# w_48912_502344# w_19323_238507# w_101616_339317#
+ photo_V4_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D3-P-b photo_V2_1/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-P-c
+ w_133508_375241# w_49300_598600# photo_V2_1/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-P-b
+ w_133508_72340# w_49020_466420# photo_V3_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D5-P-c
+ cascodetestsWithPads_0/cascodetests_N_v2_0/gnd photo_V3_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D5-P-b
XTIA_228k_0 TIA_228k_0/Vdd TIA_228k_0/Vout TIA_228k_0/Iin cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ TIA_228k
XTIA_228k_1 TIA_228k_1/Vdd TIA_228k_1/Vout TIA_228k_1/Iin cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ TIA_228k
X2G4_0 cascodetestsWithPads_0/cascodetests_N_v2_0/gnd x2G4
Xphoto_V3_0 photo_V3_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D5-P-c photo_V3_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D5-P-b
+ w_49120_634420# w_49120_646420# w_48912_502344# photo_V3_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D3-P-b
+ w_49300_598600# w_49106_550390# w_49012_682344# w_49012_670344# w_49012_658344#
+ w_49020_466420# cascodetestsWithPads_0/cascodetests_N_v2_0/gnd photo_V3
X10G_0 cascodetestsWithPads_0/cascodetests_N_v2_0/gnd x10G
Xphoto_V1_0 w_133508_375241# w_133616_339317# cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ photo_V1
Xphoto_V1_1 w_101508_375241# w_101616_339317# cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ photo_V1
Xvaractors4september_0 varactors4september
XTIA_332k_0 TIA_332k_0/Vdd TIA_332k_0/Vout TIA_332k_0/Iin cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ TIA_332k
XOTA_tb_ps8_0 OTA_tb_ps8_0/Vin1 OTA_tb_ps8_0/Vin2 OTA_tb_ps8_0/Vcasn OTA_tb_ps8_0/Vss
+ OTA_tb_ps8_0/Vout OTA_tb_ps8_0/Vdd OTA_tb_ps8_0/Vcontrol2 OTA_tb_ps8_0/Vcasp OTA_tb_ps8_0/Vbias
+ OTA_tb_ps8_0/v1 OTA_tb_ps8_0/Vcontrol1 OTA_tb_ps8_0/v2 cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ OTA_tb_ps8
Xphoto_V1_2 w_19323_72340# w_19431_36416# cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ photo_V1
Xphoto_V1_3 w_69508_375241# w_69616_339317# cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ photo_V1
XTIA_332k_1 TIA_332k_1/Vdd TIA_332k_1/Vout TIA_332k_1/Iin cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ TIA_332k
XOTA_tb_ps8_1 OTA_tb_ps8_1/Vin1 OTA_tb_ps8_1/Vin2 OTA_tb_ps8_1/Vcasn OTA_tb_ps8_1/Vss
+ OTA_tb_ps8_1/Vout OTA_tb_ps8_1/Vdd OTA_tb_ps8_1/Vcontrol2 OTA_tb_ps8_1/Vcasp OTA_tb_ps8_1/Vbias
+ OTA_tb_ps8_1/v1 OTA_tb_ps8_1/Vcontrol1 OTA_tb_ps8_1/v2 cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ OTA_tb_ps8
XTIA_542k_0 TIA_542k_0/Vdd TIA_542k_0/Vout TIA_542k_0/Iin cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ TIA_542k
XTIA_542k_1 TIA_542k_1/Vdd TIA_542k_1/Vout TIA_542k_1/Iin cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ TIA_542k
XOTA_tb_0 OTA_tb_2/Vin1 OTA_tb_2/Vin2 OTA_tb_2/Vcasn OTA_tb_2/Vss OTA_tb_2/Vb1 OTA_tb_2/Vcasp
+ OTA_tb_2/Vbias OTA_tb_2/pads$6_0/single_pad$1_0[1|3]/b_n11776_n3760# OTA_tb_2/pads$6_0/single_pad$1_0[0|0]/b_n11776_n3760#
+ OTA_tb_2/pads$6_0/single_pad$1_0[1|0]/b_n11776_n3760# OTA_tb_2/pads$6_0/single_pad$1_0[0|2]/b_n11776_n3760#
+ OTA_tb_2/m1_1326_3060# OTA_tb_2/m1_1809_4176# OTA_tb_2/pads$6_0/single_pad$1_0[1|2]/b_n11776_n3760#
+ OTA_tb_2/pads$6_0/single_pad$1_0[0|4]/b_n11776_n3760# OTA_tb_2/pads$6_0/single_pad$1_0[1|4]/b_n11776_n3760#
+ OTA_tb_2/m1_3248_6136# OTA_tb_2/m1_3342_2253# OTA_tb_2/pads$6_0/single_pad$1_0[0|1]/b_n11776_n3760#
+ OTA_tb_2/m1_1822_150# OTA_tb_2/m1_3479_7472# OTA_tb_2/pads$6_0/single_pad$1_0[0|4]/m1_n12006_n4000#
+ OTA_tb_2/m1_1629_4037# OTA_tb_2/m1_4464_n2543# OTA_tb_2/m1_3184_1154# OTA_tb_2/m4_n17596_23877#
+ OTA_tb_2/Vdd OTA_tb_2/pads$6_0/single_pad$1_0[1|1]/b_n11776_n3760# OTA_tb_2/m1_3282_6654#
+ OTA_tb_2/m1_2970_7585# OTA_tb_2/m1_1450_152# OTA_tb_2/Vout OTA_tb_2/m4_n17304_11241#
+ cascodetestsWithPads_0/cascodetests_N_v2_0/gnd OTA_tb_2/m1_1693_316# OTA_tb_2/pads$6_0/single_pad$1_0[0|3]/b_n11776_n3760#
+ OTA_tb
XOTA_tb_ps4_1 OTA_tb_ps4_1/Vin1 OTA_tb_ps4_1/Vin2 OTA_tb_ps4_1/Vcasn OTA_tb_ps4_1/Vss
+ OTA_tb_ps4_1/Vout OTA_tb_ps4_1/Vdd OTA_tb_ps4_1/Vcontrol2 OTA_tb_ps4_1/Vcasp OTA_tb_ps4_1/Vbias
+ OTA_tb_ps4_1/Vcontrol3 OTA_tb_ps4_1/Vcontrol1 cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ OTA_tb_ps4
XOTA_tb_ps4_0 OTA_tb_ps4_0/Vin1 OTA_tb_ps4_0/Vin2 OTA_tb_ps4_0/Vcasn OTA_tb_ps4_0/Vss
+ OTA_tb_ps4_0/Vout OTA_tb_ps4_0/Vdd OTA_tb_ps4_0/Vcontrol2 OTA_tb_ps4_0/Vcasp OTA_tb_ps4_0/Vbias
+ OTA_tb_ps4_0/Vcontrol3 OTA_tb_ps4_0/Vcontrol1 cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ OTA_tb_ps4
XOTA_tb_1 OTA_tb_1/Vin1 OTA_tb_1/Vin2 OTA_tb_1/Vcasn OTA_tb_1/Vss OTA_tb_1/Vb1 OTA_tb_1/Vcasp
+ OTA_tb_1/Vbias OTA_tb_1/pads$6_0/single_pad$1_0[1|3]/b_n11776_n3760# OTA_tb_1/pads$6_0/single_pad$1_0[0|0]/b_n11776_n3760#
+ OTA_tb_1/pads$6_0/single_pad$1_0[1|0]/b_n11776_n3760# OTA_tb_1/pads$6_0/single_pad$1_0[0|2]/b_n11776_n3760#
+ OTA_tb_1/m1_1326_3060# OTA_tb_1/m1_1809_4176# OTA_tb_1/pads$6_0/single_pad$1_0[1|2]/b_n11776_n3760#
+ OTA_tb_1/pads$6_0/single_pad$1_0[0|4]/b_n11776_n3760# OTA_tb_1/pads$6_0/single_pad$1_0[1|4]/b_n11776_n3760#
+ OTA_tb_1/m1_3248_6136# OTA_tb_1/m1_3342_2253# OTA_tb_1/pads$6_0/single_pad$1_0[0|1]/b_n11776_n3760#
+ OTA_tb_1/m1_1822_150# OTA_tb_1/m1_3479_7472# OTA_tb_1/pads$6_0/single_pad$1_0[0|4]/m1_n12006_n4000#
+ OTA_tb_1/m1_1629_4037# OTA_tb_1/m1_4464_n2543# OTA_tb_1/m1_3184_1154# OTA_tb_1/m4_n17596_23877#
+ OTA_tb_1/Vdd OTA_tb_1/pads$6_0/single_pad$1_0[1|1]/b_n11776_n3760# OTA_tb_1/m1_3282_6654#
+ OTA_tb_1/m1_2970_7585# OTA_tb_1/m1_1450_152# OTA_tb_1/Vout OTA_tb_1/m4_n17304_11241#
+ cascodetestsWithPads_0/cascodetests_N_v2_0/gnd OTA_tb_1/m1_1693_316# OTA_tb_1/pads$6_0/single_pad$1_0[0|3]/b_n11776_n3760#
+ OTA_tb
XOTA_tb_2 OTA_tb_2/Vin1 OTA_tb_2/Vin2 OTA_tb_2/Vcasn OTA_tb_2/Vss OTA_tb_2/Vb1 OTA_tb_2/Vcasp
+ OTA_tb_2/Vbias OTA_tb_2/pads$6_0/single_pad$1_0[1|3]/b_n11776_n3760# OTA_tb_2/pads$6_0/single_pad$1_0[0|0]/b_n11776_n3760#
+ OTA_tb_2/pads$6_0/single_pad$1_0[1|0]/b_n11776_n3760# OTA_tb_2/pads$6_0/single_pad$1_0[0|2]/b_n11776_n3760#
+ OTA_tb_2/m1_1326_3060# OTA_tb_2/m1_1809_4176# OTA_tb_2/pads$6_0/single_pad$1_0[1|2]/b_n11776_n3760#
+ OTA_tb_2/pads$6_0/single_pad$1_0[0|4]/b_n11776_n3760# OTA_tb_2/pads$6_0/single_pad$1_0[1|4]/b_n11776_n3760#
+ OTA_tb_2/m1_3248_6136# OTA_tb_2/m1_3342_2253# OTA_tb_2/pads$6_0/single_pad$1_0[0|1]/b_n11776_n3760#
+ OTA_tb_2/m1_1822_150# OTA_tb_2/m1_3479_7472# OTA_tb_2/pads$6_0/single_pad$1_0[0|4]/m1_n12006_n4000#
+ OTA_tb_2/m1_1629_4037# OTA_tb_2/m1_4464_n2543# OTA_tb_2/m1_3184_1154# OTA_tb_2/m4_n17596_23877#
+ OTA_tb_2/Vdd OTA_tb_2/pads$6_0/single_pad$1_0[1|1]/b_n11776_n3760# OTA_tb_2/m1_3282_6654#
+ OTA_tb_2/m1_2970_7585# OTA_tb_2/m1_1450_152# OTA_tb_2/Vout OTA_tb_2/m4_n17304_11241#
+ cascodetestsWithPads_0/cascodetests_N_v2_0/gnd OTA_tb_2/m1_1693_316# OTA_tb_2/pads$6_0/single_pad$1_0[0|3]/b_n11776_n3760#
+ OTA_tb
Xphoto_V4_0 photo_V4_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D3-P-b w_13120_634420#
+ w_13120_646420# w_12912_502344# w_13300_598600# w_13106_550390# w_13012_682344#
+ photo_V4_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D5-P-c w_13012_670344# photo_V4_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D5-P-b
+ w_13012_658344# w_13020_466420# cascodetestsWithPads_0/cascodetests_N_v2_0/gnd photo_V4
XTIA_126k_1 TIA_126k_1/Vdd TIA_126k_1/Vout TIA_126k_1/Iin cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ TIA_126k
XTIA_126k_0 TIA_126k_0/Vdd TIA_126k_0/Vout TIA_126k_0/Iin cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ TIA_126k
XcascodetestsWithPads_0 cascodetestsWithPads_0/cascodetests_N_v2_0/gnd cascodetestsWithPads
Xnoise_virtual_1 noise_virtual_1/noise_D[1] noise_virtual_1/noise_D[2] noise_virtual_1/noise_D[3]
+ noise_virtual_1/noise_D[0] noise_virtual_1/VVDD noise_virtual_1/VOUT noise_virtual_1/Noise_in
+ noise_virtual_1/VPWR cascodetestsWithPads_0/cascodetests_N_v2_0/gnd noise_virtual
XTIA_434k_0 TIA_434k_0/Vdd TIA_434k_0/Vout TIA_434k_0/Iin cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ TIA_434k
XMEMID_0 MEMID_0/Vread MEMID_0/Vwriteplus MEMID_0/Vwriteminus MEMID_0/Vraw MEMID_0/Vamp
+ MEMID_0/Voffset MEMID_0/Vout MEMID_0/Vdd MEMID_0/Vi1 MEMID_0/Vi2 MEMID_0/Vss cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ MEMID
Xnoise_virtual_0 noise_virtual_0/noise_D[1] noise_virtual_0/noise_D[2] noise_virtual_0/noise_D[3]
+ noise_virtual_0/noise_D[0] noise_virtual_0/VVDD noise_virtual_0/VOUT noise_virtual_0/Noise_in
+ noise_virtual_0/VPWR cascodetestsWithPads_0/cascodetests_N_v2_0/gnd noise_virtual
Xnoise_virtual_2 noise_virtual_2/noise_D[1] noise_virtual_2/noise_D[2] noise_virtual_2/noise_D[3]
+ noise_virtual_2/noise_D[0] noise_virtual_2/VVDD noise_virtual_2/VOUT noise_virtual_2/Noise_in
+ noise_virtual_2/VPWR cascodetestsWithPads_0/cascodetests_N_v2_0/gnd noise_virtual
XTIA_434k_1 TIA_434k_1/Vdd TIA_434k_1/Vout TIA_434k_1/Iin cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ TIA_434k
XMEMID_1 MEMID_1/Vread MEMID_1/Vwriteplus MEMID_1/Vwriteminus MEMID_1/Vraw MEMID_1/Vamp
+ MEMID_1/Voffset MEMID_1/Vout MEMID_1/Vdd MEMID_1/Vi1 MEMID_1/Vi2 MEMID_1/Vss cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ MEMID
Xphoto_V2_1 w_19531_370583# w_19531_382583# w_19323_238507# photo_V2_1/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-P-c
+ photo_V2_1/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-P-b w_19711_334763# w_19517_286553#
+ w_19423_418507# w_19423_406507# w_19423_394507# photo_V2_1/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D3-P-b
+ w_19431_202583# cascodetestsWithPads_0/cascodetests_N_v2_0/gnd photo_V2
Xphoto_V2_0 w_133716_204416# w_133716_216416# w_133508_72340# photo_V2_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-P-c
+ photo_V2_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-P-b w_133896_168596# w_133702_120386#
+ w_133608_252340# w_133608_240340# w_133608_228340# photo_V2_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D3-P-b
+ w_133616_36416# cascodetestsWithPads_0/cascodetests_N_v2_0/gnd photo_V2
Xnoise_virtual_3 noise_virtual_3/noise_D[1] noise_virtual_3/noise_D[2] noise_virtual_3/noise_D[3]
+ noise_virtual_3/noise_D[0] noise_virtual_3/VVDD noise_virtual_3/VOUT noise_virtual_3/Noise_in
+ noise_virtual_3/VPWR cascodetestsWithPads_0/cascodetests_N_v2_0/gnd noise_virtual
XTIA_644k_0 TIA_644k_0/Vdd TIA_644k_0/Vout TIA_644k_0/Iin cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ TIA_644k
XsurfaceTestArray_0 surfaceTestArray
XTIA_644k_1 TIA_644k_1/Vdd TIA_644k_1/Vout TIA_644k_1/Iin cascodetestsWithPads_0/cascodetests_N_v2_0/gnd
+ TIA_644k
XMPW7_GWU_0 MPW7_GWU_0/Vb_2 MPW7_GWU_0/vgnd MPW7_GWU_0/Vdd MPW7_GWU_0/Vb_1 MPW7_GWU_0/G_2
+ MPW7_GWU_0/G_1 MPW7_GWU_0/TE cascodetestsWithPads_0/cascodetests_N_v2_0/gnd MPW7_GWU_0/DIODE_2
+ MPW7_GWU_0/DIODE_1 MPW7_GWU
XsurfaceTestArray_1 surfaceTestArray
XsurfaceTestArray_2 surfaceTestArray
.ends

.subckt user_analog_project_wrapper io_analog[4] io_analog[5] io_analog[6] wb_clk_i
+ wb_rst_i wbs_ack_o wbs_adr_i[0] wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13]
+ wbs_adr_i[14] wbs_adr_i[15] wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[1] wbs_adr_i[2]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[1] wbs_dat_i[2] wbs_dat_i[3] wbs_dat_i[4]
+ wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8] wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10]
+ wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13] wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16]
+ wbs_dat_o[1] wbs_dat_o[2] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6] wbs_dat_o[7]
+ wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3] wbs_stb_i
+ wbs_we_i wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_adr_i[18] wbs_dat_i[20] wbs_dat_i[21]
+ wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25] wbs_dat_i[26] wbs_dat_i[27]
+ wbs_dat_i[28] wbs_dat_i[29] wbs_adr_i[19] wbs_dat_i[30] wbs_dat_i[31] la_oenb[0]
+ wbs_adr_i[20] wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25]
+ wbs_adr_i[26] wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] la_oenb[1] wbs_adr_i[30]
+ wbs_adr_i[31] la_oenb[2] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19] la_oenb[3] wbs_dat_o[20]
+ wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24] wbs_dat_o[25] wbs_dat_o[26]
+ wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] la_oenb[4] wbs_dat_o[30] wbs_dat_o[31]
+ la_oenb[5] la_data_in[0] la_data_in[1] la_data_in[2] la_data_in[3] la_data_in[4]
+ la_data_in[5] la_data_out[0] la_data_out[1] la_data_out[2] la_data_out[3] la_data_out[4]
+ la_data_out[5] la_data_in[23] la_data_in[24] la_data_in[25] la_oenb[6] la_oenb[7]
+ la_oenb[8] la_oenb[9] la_data_in[26] la_data_in[11] la_data_in[12] la_data_in[13]
+ la_data_in[14] la_data_in[6] la_data_in[7] la_data_in[8] la_data_in[9] la_data_in[15]
+ la_data_out[10] la_data_out[11] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_in[16] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[10] la_data_out[6]
+ la_data_out[7] la_data_out[8] la_data_out[9] la_data_in[20] la_oenb[10] la_oenb[11]
+ la_oenb[12] la_oenb[13] la_oenb[14] la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18]
+ la_oenb[19] la_data_in[21] la_oenb[20] la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24]
+ la_oenb[25] la_data_in[22] la_data_in[39] la_oenb[45] la_data_in[40] la_data_out[26]
+ la_data_out[27] la_data_out[28] la_data_out[29] la_data_in[41] la_data_out[30] la_data_out[31]
+ la_data_out[32] la_data_out[33] la_data_out[34] la_data_out[35] la_data_out[36]
+ la_data_out[37] la_data_out[38] la_data_out[39] la_data_in[42] la_data_out[40] la_data_out[41]
+ la_data_out[42] la_data_out[43] la_data_out[44] la_data_out[45] la_data_out[46]
+ la_data_in[43] la_data_in[44] la_data_in[45] la_data_in[46] la_oenb[46] la_oenb[38]
+ la_oenb[39] la_oenb[37] la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_oenb[44] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_oenb[26]
+ la_oenb[27] la_oenb[28] la_oenb[29] la_data_in[38] la_oenb[30] la_oenb[31] la_oenb[32]
+ la_oenb[33] la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[47] la_oenb[48] la_oenb[49]
+ la_oenb[50] la_oenb[51] la_oenb[52] la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56]
+ la_oenb[57] la_oenb[58] la_oenb[59] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63]
+ la_oenb[64] la_oenb[65] la_oenb[66] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54] la_data_in[55]
+ la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[60] la_data_in[61]
+ la_data_in[62] la_data_in[63] la_data_out[47] la_data_out[48] la_data_out[49] la_data_in[64]
+ la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_in[65] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_in[66] la_data_in[67] la_data_in[72]
+ la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76] la_data_in[77] la_data_in[78]
+ la_data_in[79] la_data_in[80] la_data_in[81] la_data_in[82] la_data_in[83] la_data_in[84]
+ la_data_in[85] la_data_in[86] la_data_in[87] la_data_in[69] la_oenb[67] la_oenb[68]
+ la_oenb[69] la_oenb[70] la_oenb[71] la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75]
+ la_oenb[76] la_oenb[77] la_oenb[78] la_oenb[79] la_oenb[80] la_oenb[81] la_oenb[82]
+ la_oenb[83] la_oenb[84] la_oenb[85] la_oenb[86] la_oenb[87] la_data_out[68] la_data_out[69]
+ la_data_in[70] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_in[71] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_in[68] la_oenb[88] la_oenb[89]
+ la_oenb[90] la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96]
+ la_oenb[97] la_oenb[98] la_oenb[99] la_data_in[101] la_data_in[102] la_data_in[103]
+ la_data_in[104] la_data_in[105] la_data_in[106] la_data_in[107] la_data_in[108]
+ la_data_in[100] la_data_in[90] la_data_in[91] la_data_in[92] la_data_in[93] la_data_in[94]
+ la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98] la_data_in[99] la_data_out[100]
+ la_data_out[101] la_data_out[102] la_data_out[103] la_data_out[104] la_data_out[105]
+ la_data_out[93] la_data_out[106] la_data_out[94] la_data_out[107] la_data_out[95]
+ la_data_out[96] la_data_out[108] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[92] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_data_in[88] la_data_in[89] la_data_out[88]
+ la_data_out[89] la_data_out[90] la_data_out[91] la_data_in[119] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_in[116] la_data_in[117] la_data_out[123]
+ la_data_in[112] la_data_out[124] la_data_out[125] la_data_out[126] la_data_out[127]
+ la_data_in[118] la_oenb[109] la_data_in[120] la_oenb[110] la_data_in[121] la_oenb[111]
+ la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117] la_oenb[118]
+ la_oenb[119] la_data_in[122] la_data_in[123] la_oenb[120] la_oenb[121] la_oenb[122]
+ la_oenb[123] la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_data_in[124]
+ la_data_in[125] la_data_in[126] la_data_in[127] la_data_out[110] user_clock2 user_irq[0]
+ la_data_in[113] user_irq[1] la_data_in[114] user_irq[2] la_data_out[111] la_data_out[112]
+ la_data_out[109] la_data_in[109] la_data_out[113] la_data_in[110] la_data_out[114]
+ la_oenb[108] la_data_out[115] la_data_out[116] la_data_in[111] la_data_out[117]
+ la_data_in[115] la_data_out[118] la_data_out[119] gpio_analog[2] gpio_analog[3]
+ gpio_analog[4] gpio_analog[5] gpio_analog[6] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4]
+ gpio_noesd[5] gpio_noesd[6] io_analog[0] io_analog[1] io_analog[2] io_analog[3]
+ io_clamp_high[0] io_clamp_low[0] io_in[10] io_in[11] io_in[12] io_in[13] io_in[9]
+ io_in_3v3[10] io_in_3v3[11] io_in_3v3[12] io_in_3v3[13] io_in_3v3[9] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[9] io_out[10] io_out[11] io_out[12] io_out[13]
+ io_out[9] vccd1 vdda1 vssa1 io_in[16] io_in[17] gpio_analog[9] gpio_noesd[10] io_analog[7]
+ io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_analog[8] io_analog[9]
+ gpio_noesd[7] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] gpio_noesd[8] io_clamp_high[1]
+ io_clamp_high[2] gpio_noesd[9] io_clamp_low[1] io_out[14] io_out[15] io_out[16]
+ io_out[17] io_clamp_low[2] gpio_analog[10] io_analog[10] vccd2 gpio_analog[7] gpio_analog[8]
+ io_in[14] io_in[15] vssa2 io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] gpio_analog[16]
+ gpio_analog[17] gpio_analog[11] gpio_analog[12] gpio_noesd[11] io_in[18] io_in[19]
+ io_in[20] io_in[21] io_oeb[18] io_oeb[19] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23]
+ io_oeb[24] io_oeb[25] io_oeb[26] io_in[22] io_in[23] io_in[24] io_in[25] io_in[26]
+ gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] io_out[18] io_out[19]
+ io_out[20] io_out[21] io_out[22] io_out[23] io_out[24] io_out[25] io_out[26] gpio_noesd[16]
+ gpio_noesd[17] gpio_analog[13] gpio_analog[14] gpio_analog[15] io_in_3v3[18] io_in_3v3[19]
+ vdda2 io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23] vssd2 io_in_3v3[6]
+ io_in_3v3[7] io_in_3v3[8] io_in[1] io_oeb[0] gpio_noesd[0] io_in[2] io_in[3] io_in[4]
+ io_in[5] io_out[1] io_in[6] io_in_3v3[1] io_in[7] io_in[8] gpio_analog[0] io_oeb[1]
+ io_in_3v3[0] io_out[2] io_out[3] io_out[4] io_out[5] io_out[6] io_out[7] io_out[8]
+ gpio_analog[1] gpio_noesd[1] io_in[0] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4] io_oeb[2]
+ io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8] vssd1 io_in_3v3[5] io_out[0]
XTOP_0 w_19531_382583# w_13120_646420# TOP_0/photo_V2_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-P-c
+ w_133616_36416# TOP_0/photo_V2_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-P-b w_133608_228340#
+ w_133616_339317# w_19531_370583# w_49012_658344# w_13120_634420# w_12912_502344#
+ w_49012_682344# w_133896_168596# w_133608_252340# w_49106_550390# w_19323_72340#
+ w_19711_334763# w_49012_670344# w_19431_202583# w_133608_240340# w_13300_598600#
+ w_19431_36416# TOP_0/photo_V2_1/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D3-P-b w_13020_466420#
+ TOP_0/photo_V3_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D3-P-b w_133716_216416#
+ w_69508_375241# TOP_0/photo_V4_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D5-P-c w_19423_418507#
+ w_13012_658344# TOP_0/photo_V2_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D3-P-b TOP_0/photo_V4_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D5-P-b
+ w_133716_204416# w_19517_286553# w_19423_406507# w_13106_550390# w_13012_682344#
+ w_13012_670344# w_133702_120386# w_69616_339317# w_101508_375241# w_49120_646420#
+ w_19423_394507# w_49120_634420# w_48912_502344# w_19323_238507# w_101616_339317#
+ TOP_0/photo_V4_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4_0/D3-P-b TOP_0/photo_V2_1/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-P-c
+ w_133508_375241# w_49300_598600# TOP_0/photo_V2_1/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$3_0/D5-P-b
+ w_133508_72340# w_49020_466420# TOP_0/photo_V3_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D5-P-c
+ TOP_0/cascodetestsWithPads_0/cascodetests_N_v2_0/gnd TOP_0/photo_V3_0/sky130_fd_pr__nfet_01v8_lvt_D7LUG4$2_0/D5-P-b
+ TOP
.ends
